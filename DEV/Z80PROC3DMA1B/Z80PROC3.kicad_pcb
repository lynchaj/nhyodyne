# Repository lynchaj/nhyodyne (continued)

## KiCad design 6502PERI/Z80-6502IO.kicad_pcb

File 6502PERI/readme.md:

README
February 25, 2022 at 10:45:13 AM EST

This board (hopefully) will provide a CPU6502-specific multi-IO capability consisting of
a 65C22 VIA, 65C51 ACIA, and a 6581 SID sound device.

Open Items
==========

1.	Actual design has not yet been tested, but is based on existing designs, so
	there should be no reason why it wouldn't work.
	
2.	Regarding the I/O port allocation, depending on which functions remain in the 
	final design, there may be an opportunity to remove the DIP switches and replace
	with two jumpers. The SID requires a 32-byte block of port addresses, the VIA 
	requires 16, and the ACIA requires 4. Thus, blocks are allocated in 64-byte 
	chunks. Using this board will likely limit the number of other MBC boards that 
	can co-exist with it and/or greatly change the port allocations such that changes
	to RomWBW might be needed.

3.	Board real estate is exceedingly tight and there's no room for the additional
	circuitry required to derive the PHI1 clock from the main system clock.
	All of the spare pins on the main buss connector have been allocated, so for this
	development version, there's a tie point next to the 65C22 which should
	connect with a "flying lead" to the clock on the MBC6502 CPU card. As such,
	these cards should be kept next to each other. If chip functions are removed
	from the board (i.e., eliminating the 65C51 or the SID), then there would be
	room for an on-board clock divider. Since the 6502-specific software already 
	utilizes the console board, there may be limited use for this function and
	eliminating it would create the necessary room.
	
4.	Again, due to board space, the serial output of the 65C51 is brought out to a
	1x6 0.1" header for use with a TTL-to-USB converter.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C19, C20, C21: 0.1u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C9, C10, C11: 10u; CP_Radial_D5.0mm_P2.50mm
C12, C13: 0.22uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C14, C17, C18: 4.7uF; CP_Radial_D5.0mm_P2.50mm
C15, C16: 2200pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1, D2: LED; LED_D3.0mm
H1, H2: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J1: RCJ-014; CUI_RCJ-014
K1, K2: INT SRC; PinHeader_1x03_P2.54mm_Vertical
K3: HANDS; PinHeader_1x03_P2.54mm_Vertical
P1: CONN_1; PinHeader_1x01_P2.54mm_Vertical
P2: Z80 BUS INTERFACE; PinHeader_2x25_P2.54mm_Horizontal
P3: SERIAL; PinHeader_1x06_P2.54mm_Vertical
P4: USB_PWR; PinHeader_1x02_P2.54mm_Vertical
P5: PPI; PinHeader_2x14_P2.54mm_Horizontal
R1, R2: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 1.0KQ; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 10KQ; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RR1: 10K; R_Array_SIP9
SW1: IO PORT ADDR; SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm
U1, U3: 74LS244; DIP-20_W7.62mm
U2: 74LS245; DIP-20_W7.62mm
U4: 74LS04; DIP-14_W7.62mm_Socket
U5: 74LS32; DIP-14_W7.62mm_Socket
U6: 74LS139; DIP-16_W7.62mm_Socket
U7: 74LS688; DIP-20_W7.62mm_Socket
U8: W65C51NxP; DIP-28_W15.24mm_Socket
U9: W65C22SxP; DIP-40_W15.24mm_Socket
U10: 6581; DIP-28_W15.24mm_Socket
U11: MAX662ACPA+; DIP-8_W7.62mm_Socket
U12: OPA2134; DIP-8_W7.62mm_Socket
X1: 1.8432MHz; Oscillator_DIP-8

Connections:
+12V: C14.1, U10.28 (+12V), U11.6 (VOUT), U12.8 (V+)
/688SEL#: U3.9 (O0b), U7.1 (G)
A0: P2.21, U1.2 (I0a)
A1: P2.19, U1.4 (I1a)
A2: P2.17, U1.6 (I2a)
A3: P2.15, U1.8 (I3a)
A4: P2.13, U1.11 (I0b)
A5: P2.11, U1.13 (I1b)
A6: P2.9, U1.15 (I2b)
A7: P2.7, U1.17 (I3b)
A8: P2.5
A9: P2.3
A10: P2.1
A11: P2.2
A12: P2.4
A13: P2.6
A14: P2.8
A15: P2.10
BOARD_CS#: U2.19 (CE), U3.4 (I1a), U6.1 (E), U7.19 (P=R)
BUSACK#: P2.35
BUSRQ#: P2.31
CA1: P5.17, U9.40 (CA1)
CA2: P5.19, U9.39 (CA2)
CB1: P5.18, U9.18 (CB1)
CB2: P5.20, U9.19 (CB2)
CLK: P2.12
CS_ACIA1#: U6.6 (O2), U8.3 (~CS2)
CS_SID#: U6.7 (O3), U10.8 (~CS)
CS_VIA1#: U6.4 (O0), U9.23 (~CS2)
CTS: K3.1, U8.9 (~CTS)
D0: P2.28, U2.2 (A0)
D1: P2.30, U2.3 (A1)
D2: P2.24, U2.4 (A2)
D3: P2.16, U2.5 (A3)
D4: P2.14, U2.6 (A4)
D5: P2.18, U2.7 (A5)
D6: P2.20, U2.8 (A6)
D7: P2.26, U2.9 (A7)
DSR: K3.3, U8.17 (~DSR)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C14.2, C17.2, C19.2, C20.2, C21.2, D2.1 (K), H1.1, H2.1, J1.1A (1), J1.1B (1), J1.1C (1), P2.23, P3.1, P5.26 (P22), R3.1, R4.1, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, U1.1 (OEa), U1.10 (GND), U1.19 (OEb), U2.10 (GND), U3.1 (OEa), U3.10 (GND), U3.19 (OEb), U4.7 (GND), U5.7 (GND), U6.8 (GND), U7.10 (GND), U8.1 (VSS), U9.1 (VSS), U10.14 (GND), U11.7 (GND), U11.8 (SHDN), U12.4 (V-), X1.4 (GND)
HALT#: P2.36
INT#: K1.1, K2.1, P2.32
IORQ#: P2.40, U3.11 (I0b)
IRQA#: K2.2 (PM), U8.26 (~IRQ)
IRQV#: K1.2 (PM), U9.21 (~IRQ)
M1#: P2.27, U3.13 (I1b)
MREQ#: P2.38
NMI#: K1.3, K2.3, P2.34
unnamed: C12.1, U11.2 (C1+)
unnamed: C12.2, U11.1 (C1-)
unnamed: C13.1, U11.4 (C2+)
unnamed: C13.2, U11.3 (C2-)
unnamed: C15.1, U10.1 (CAP1A)
unnamed: C15.2, U10.2 (CAP1B)
unnamed: C16.1, U10.3 (CAP2A)
unnamed: C16.2, U10.4 (CAP2B)
unnamed: C18.1, U12.1, U12.2 (-)
unnamed: C18.2, J1.2, R4.2
unnamed: D1.1 (K), U3.16 (O1a)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: K3.2 (PM), P3.6
unnamed: P3.3, P4.1
unnamed: R3.2, U10.27 (AUDIO_OUT), U12.3 (+)
unnamed: RR1.2, U7.3 (R0)
unnamed: RR1.3, U7.5 (R1)
unnamed: RR1.4, U7.7 (R2)
unnamed: RR1.5, U7.9 (R3)
unnamed: RR1.6, U7.12 (R4)
unnamed: RR1.7, U7.14 (R5)
unnamed: RR1.8, SW1.15, U7.16 (R6)
unnamed: RR1.9, SW1.16, U7.18 (R7)
unnamed: U4.2, U5.1
unnamed: U8.6 (XTAL1), X1.5 (OUT)
PA0: P5.1, U9.2 (PA0)
PA1: P5.3, U9.3 (PA1)
PA2: P5.5, U9.4 (PA2)
PA3: P5.7, U9.5 (PA3)
PA4: P5.9, U9.6 (PA4)
PA5: P5.11, U9.7 (PA5)
PA6: P5.13, U9.8 (PA6)
PA7: P5.15, U9.9 (PA7)
PB0: P5.2, U9.10 (PB0)
PB1: P5.4, U9.11 (PB1)
PB2: P5.6, U9.12 (PB2)
PB3: P5.8, U9.13 (PB3)
PB4: P5.10, U9.14 (PB4)
PB5: P5.12, U9.15 (PB5)
PB6: P5.14, U9.16 (PB6)
PB7: P5.16, U9.17 (PB7)
RD#: P2.39, U2.1 (A->B), U3.17 (I3b)
RESET#: P2.29, U3.2 (I0a)
RFSH#: P2.25
RTS: P3.2, U8.8 (~RTS)
RxD: P3.4, U8.12 (RxD)
SLAVE_CLK: P1.1, U8.27 (ϕ2), U9.25 (ϕ2), U10.6 (ϕ2)
SPARE0: P2.42
SPARE1: P2.44
SPARE2: P2.46
SPARE3: P2.48
SPARE4: P2.50
SPARE5: P2.49
SPARE6: P2.47
SPARE7: P2.45
SPARE8: P2.43
SPARE9: P2.41
TxD: P3.5, U8.10 (TxD)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C17.1, C19.1, C20.1, C21.1, P2.22, P4.2 (PM), P5.25 (P24), R1.2, R2.2, RR1.1 (COM), U1.20 (VCC), U2.20 (VCC), U3.20 (VCC), U4.14 (VCC), U5.14 (VCC), U6.16 (VCC), U7.20 (VCC), U8.2 (CS1), U8.15 (VCC), U9.20 (VCC), U9.24 (CS1), U10.25 (+5V), U11.5 (VCC), X1.1 (EN), X1.8 (Vcc)
WAIT#: P2.33
WR#: P2.37, U3.15 (I2b)
bA0: U1.18 (O0a), U8.13 (RS0), U9.38 (RS0), U10.9 (A0)
bA1: U1.16 (O1a), U8.14 (RS1), U9.37 (RS1), U10.10 (A1)
bA2: U1.14 (O2a), U9.36 (RS2), U10.11 (A2)
bA3: U1.12 (O3a), U9.35 (RS3), U10.12 (A3)
bA4: U1.9 (O0b), U6.2 (A0), U10.13 (A4)
bA5: U1.7 (O1b), U6.3 (A1)
bA6: U1.5 (O2b), U7.15 (P6)
bA7: U1.3 (O3b), U7.17 (P7)
bD0: U2.18 (B0), U8.18 (D0), U9.33 (D0), U10.15 (D0)
bD1: U2.17 (B1), U8.19 (D1), U9.32 (D1), U10.16 (D1)
bD2: U2.16 (B2), U8.20 (D2), U9.31 (D2), U10.17 (D2)
bD3: U2.15 (B3), U8.21 (D3), U9.30 (D3), U10.18 (D3)
bD4: U2.14 (B4), U8.22 (D4), U9.29 (D4), U10.19 (D4)
bD5: U2.13 (B5), U8.23 (D5), U9.28 (D5), U10.20 (D5)
bD6: U2.12 (B6), U8.24 (D6), U9.27 (D6), U10.21 (D6)
bD7: U2.11 (B7), U8.25 (D7), U9.26 (D7), U10.22 (D7)
bM1#: U3.7 (O1b), U7.2 (P0), U7.4 (P1), U7.6 (P2), U7.8 (P3), U7.11 (P4), U7.13 (P5)
bRD#: U3.3 (O3b), U4.1
bRESET#: U3.18 (O0a), U8.4 (~RES), U9.34 (~RES), U10.5 (~RES)
bRW#: U5.3, U8.28 (R/~W), U9.22 (R/~W), U10.7 (R/~W)
bWR#: U3.5 (O2b), U5.2

Notes on the sheet:
Note: Bus connector is mirror image of Z80 CPU pin out to mate to backplane whose connectors reflect Z80 CPU pin out.
Note: IO Address Port 64-byte blocks S1=on - A7 (low) S2=off - A6 (high) S3=off - A5 (no effect) S4=on - A4 (no effect) S5=on - A3 (no effect) S6=on - A2 (no effect) S7=x - A1 (no effect) S8=x - A0 (no effect)
Note: Inhibit Board Operation During Interrupts M1# = low, IORQ# = low
Note: Buffers/Transceivers respond to IO and MEM cycles
Z80 BUS INTERFACE
IO SELECTION CIRCUIT
SET IO PORT
IO CHIP SELECT
42=Vcc 43=GND

Board: 2 copper layers, 100.0 x 100.0 mm, 53 parts (0 on the bottom side), 106 nets.

## KiCad design Z80PRINT1/Z80PRINT.kicad_pcb

File Z80PRINT1/ReadMe.md:

# Z80 PRINT V1

Provides bi-directional 8 bit parallel port with buffering and full handshake and control signals

Centronics and IBM PC compatible with optional interrupt capability

Power, chip select, interrupt, and two status LEDs

IO ports $E8-$EB

# Jumpers

K1 interrupt select INT# or NMI#, interrupt can optionally be fed to IM2 circuit on Z80 processor board via flying lead

Board: 2 copper layers, 100.0 x 100.0 mm, 68 parts (0 on the bottom side), 120 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C12, C13, C14, C15, C25: 0.1u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C10, C11: 10u; CP_Radial_D5.0mm_P2.50mm
C16, C17, C18, C19, C20, C21, C22, C23, C24: 2.2nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1, D2, D3, D4, D5: LED; LED_D3.0mm
H1, H2: BRACKET; MountingHole_2.2mm_M2_Pad
K1: INT SEL; PinHeader_1x03_P2.54mm_Horizontal
P1: SPARES; PinHeader_1x10_P2.54mm_Vertical
P2: Z80 BUS BACKPLANE; PinHeader_2x25_P2.54mm_Horizontal
P3: DAISY CHAIN; PinHeader_1x04_P2.54mm_Vertical
P31: PARALLEL; PinHeader_2x13_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R9: 27; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10, R11, R12, R13, R14: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RR1: 10K; R_Array_SIP9
RR3: 4700; R_Array_SIP10
SW1: IO PORT ADDR; SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm
U1, U3, U27, U28, U29: 74LS244; DIP-20_W7.62mm
U2: 74LS245; DIP-20_W7.62mm
U4: 74LS139; DIP-16_W7.62mm
U5: 74LS32; DIP-14_W7.62mm
U6: 74LS688; DIP-20_W7.62mm
U21: 74LS04; DIP-14_W7.62mm
U25, U26: 74LS374; DIP-20_W7.62mm
U30: 74LS06; DIP-14_W7.62mm
U32: 74LS08; DIP-14_W7.62mm

Connections:
/688SEL#: U3.9, U6.1
//BUSY: P31.21, U30.1
//LINEFEED: P31.2, RR3.3, U21.11, U30.8
//PARIN0: U4.4, U27.1, U27.19
//PARIN1: U4.5, U28.1, U28.2, U28.4, U28.6, U28.19
//PARIN2: U4.6, U29.1, U29.19
//PAROUT0: U4.12, U25.11
//PAROUT2: U4.10, U26.11
//PDENBL: U25.1, U26.15, U29.13
//SEL: P31.8, RR3.5, U21.13, U30.4
//STROBE: C24.1, P31.1, R9.1, RR3.2, U21.9
/A0: P2.21, U1.2
/A1: P2.19, U1.4
/A2: P2.17, U1.6
/A3: P2.15, U1.8
/A4: P2.13, U1.11
/A5: P2.11, U1.13
/A6: P2.9, U1.15
/A7: P2.7, U1.17
/ACK: P31.19, U21.3, U28.15
/BUSY: RR3.6, U28.17, U30.2
/CS_PAR#: U2.19, U3.4, U5.9, U5.12, U6.19
/D0: P2.28, U2.2
/D1: P2.30, U2.3
/D2: P2.24, U2.4
/D3: P2.16, U2.5
/D4: P2.14, U2.6
/D5: P2.18, U2.7
/D6: P2.20, U2.8
/D7: P2.26, U2.9
/ERROR: P31.4, U28.8
/INT#: K1.1, P2.32
/IORQ#: P2.40, U3.11
/M1#: P2.27, U3.13
/NMI#: K1.3, P2.34
/P-RESET: P31.6, RR3.4, U29.6, U30.10
/PAPEROUT: P31.23, U28.13
/PARINT: U26.12, U29.11, U32.4
/PD0: C16.1, P31.3, R1.1, U27.2
/PD1: C17.1, P31.5, R5.1, U27.4
/PD2: C18.1, P31.7, R2.1, U27.6
/PD3: C19.1, P31.9, R6.1, U27.8
/PD4: C20.1, P31.11, R3.1, U27.11
/PD5: C21.1, P31.13, R7.1, U27.13
/PD6: C22.1, P31.15, R4.1, U27.15
/PD7: C23.1, P31.17, R8.1, U27.17
/RD#: P2.39, U2.1, U3.17
/RESET#: P2.29, U3.2
/SELECT: P31.25, U28.11
/SPARE0: P1.1, P2.42
/SPARE1: P1.2, P2.44
/SPARE2: P1.3, P2.46
/SPARE3: P1.4, P2.48
/SPARE4: P1.5, P2.50
/SPARE5: P1.6, P2.49
/SPARE6: P1.7, P2.47
/SPARE7: P1.8, P2.45
/SPARE8: P1.9, P2.43
/SPARE9: P1.10, P2.41
/STATUS0: D4.1, P31.26, U26.16, U29.15
/STATUS1: D5.1, U26.19, U29.17
/WR#: P2.37, U3.15
/bA0: U1.18, U4.2, U4.14
/bA1: U1.16, U4.3, U4.13
/bA2: U1.14, U6.6
/bA3: U1.12, U6.8
/bA4: U1.9, U6.11
/bA5: U1.7, U6.13
/bA6: U1.5, U6.15
/bA7: U1.3, U6.17
/bD0: U2.18, U25.3, U26.3, U27.18, U28.18, U29.18
/bD1: U2.17, U25.4, U26.4, U27.16, U28.16, U29.16
/bD2: U2.16, U25.7, U26.7, U27.14, U28.14, U29.14
/bD3: U2.15, U25.8, U26.8, U27.12, U28.12, U29.12
/bD4: U2.14, U25.13, U26.13, U27.9, U28.9, U29.9
/bD5: U2.13, U25.14, U26.14, U27.7, U28.7, U29.7
/bD6: U2.12, U25.17, U26.17, U27.5, U28.5, U29.5
/bD7: U2.11, U25.18, U26.18, U27.3, U28.3, U29.3
/bM1#: U3.7, U6.2, U6.4
/bRD#: U3.3, U5.10
/bWR#: U3.5, U5.13
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, D2.1, H1.1, H2.1, P2.23, P31.10, P31.12, P31.14, P31.16, P31.18, P31.20, P31.22, P31.24, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, U1.1, U1.10, U1.19, U2.10, U3.1, U3.10, U3.19, U4.8, U5.7, U6.10, U21.7, U25.10, U26.1, U26.10, U27.10, U28.10, U29.10, U30.7, U32.7
unnamed: D1.1, U3.16
unnamed: D1.2, R12.1
unnamed: D2.2, R13.1
unnamed: D3.1, U32.3
unnamed: D3.2, R10.1
unnamed: D4.2, R11.1
unnamed: D5.2, R14.1
unnamed: K1.2, U30.12, U32.1, U32.2
unnamed: R1.2, U25.2
unnamed: R2.2, U25.6
unnamed: R3.2, U25.12
unnamed: R4.2, U25.16
unnamed: R5.2, U25.5
unnamed: R6.2, U25.9
unnamed: R7.2, U25.15
unnamed: R8.2, U25.19
unnamed: R9.2, U30.6
unnamed: RR1.2, U6.3
unnamed: RR1.3, U6.5
unnamed: RR1.4, SW1.11, U6.7
unnamed: RR1.5, SW1.12, U6.9
unnamed: RR1.6, SW1.13, U6.12
unnamed: RR1.7, SW1.14, U6.14
unnamed: RR1.8, SW1.15, U6.16
unnamed: RR1.9, SW1.16, U6.18
unnamed: U4.1, U5.8
unnamed: U4.15, U5.11
unnamed: U21.4, U32.5
unnamed: U21.5, U26.6
unnamed: U21.6, U30.11
unnamed: U21.8, U29.2
unnamed: U21.10, U29.4
unnamed: U21.12, U29.8
unnamed: U26.2, U30.5
unnamed: U26.5, U30.9
unnamed: U26.9, U30.3
unnamed: U30.13, U32.6
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C25.1, P2.22, R10.2, R11.2, R12.2, R13.2, R14.2, RR1.1, RR3.1, U1.20, U2.20, U3.20, U4.16, U5.14, U6.20, U21.14, U25.20, U26.20, U27.20, U28.20, U29.20, U30.14, U32.14

## Commit log (part)

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2021-12-07 Add files via upload
    Pictures of VDCv1, including front, rear (with \RES modification) and picture of "composite sync hack".
2021-12-07 Add files via upload
    Picture of the front of the KBDMSEv1, also showing the keyboard dongle (which is a panel-mount DIN6 connector with 0.1" header attached).
2021-12-12 Add 65C02 designs and code
2021-12-13 Rename kbdtest.asm to kbdtest1.asm
2021-12-13 Rename kbdtest.asm to kbdtest.asm.orig
2021-12-13 Rename kbdtest1.asm to kbdtest.asm
2021-12-14 correct issues with WR
2021-12-14 update monitor
2021-12-14 update PCB
2021-12-14 Update kbdtest.asm
    - Update scan code translations.
2021-12-18 6502 software work
2021-12-22 resolve conflict
2021-12-22 sync
2021-12-22 6502 updates
2021-12-22 Update Keyboard Utilities
    - Updated vdctest and kbdtest to ensure keyboard controller translation is on which is expected by the programs.
    - Added kbdinfo which dumps some low-level keyboard information.
2021-12-23 KBDINFO Update
    Added a few more tests and cleaned up the code. This will be the final update unless there are issues.
2021-12-24 DOS65 work
2021-12-26 6502 BOM update
2021-12-27 6502 BOM
2021-12-29 DOS/65 hardware support work
2021-12-30 6502 DOS65 slices functionality
2021-12-30 add CPM.CO6 command and convert build to Makefile
2021-12-30 setup c compiler
2021-12-30 begin work on assign.co6
2022-01-01 assign.co6 complete
2022-01-01 source clean up
2022-01-01 WORK ON MD DEVICES
2022-01-01 memory disk drivers
2022-01-01 alloc program ported
2022-01-01 dos65 utilities
2022-01-02 readme update
2022-01-08 Add ps2info
    - Replaced kbdinfo with ps2info
2022-01-17 DOS updates
2022-01-19 PCB update
2022-01-23 HDD partition adjustments
2022-02-06 properly deal with IRQ
2022-02-06 Fix DOS65 Slice compatibility issue
2022-02-19 maintenance
2022-02-20 Fix RomWBW read only filesystem dir bug
2022-02-25 Initial commit of a 6502-oriented multi-peripheral board for the MBC series.
    Initial commit of design files.
2022-02-27 autodetect hd512 and hd1024 images
2022-02-27 clean up build files
2022-03-20 work to fox sedit
2022-03-25 Z80PRINT test program add
2022-04-19 correct DOS65 file create bug
2022-04-24 reorganize DOS65
2022-04-25 Add banked driver support to DOS65
2022-04-25 Move serial device to paged ram
2022-04-25 Driver Work
2022-05-01 relocate dos65
2022-06-15 fix inverter
2022-06-16 add pull up
2022-06-18 disable floppy in DOS65 as it is a work in process
2022-07-26 6809 CPU Board
2022-08-02 Add 6809 Test Programs
2022-08-04 DMA V3
    DMA Daisy chain corrections
2022-08-12 correct zloader assemble issue
2022-08-12 add ground plane
2022-08-13 Correct prototype hardware issues
2022-08-13 Correct README
2022-08-14 Flex 09 initial
2022-08-14 flex console driver work
2022-08-15 add ppide drivers
2022-09-04 finish PPIDE read
2022-09-04 write sector
2022-09-05 add disk images
2022-09-06 6502 Doc update
2022-09-10 flex DSKY code
2022-09-11 DSKY flex drivers
2022-09-11 flex floppy drivers
2022-09-25 Add files via upload
    Sample MBC configuration file for Andrew Lynch system
2022-10-03 work to resolve cpu concurrency issues
2022-10-17 Add files via upload
    Test files for the ACIA and SID. ACIA code likely needs some work.
2022-10-22 Correct 6502 gerber
2022-11-20 Update 6809 address
2022-11-28 Add floppy support to DOS65
2022-12-30 DOS65 cleanup
2022-12-30 Fix DSKY prescaler
2023-01-01 DOS65 format utility
2023-01-02 work on ROM
2023-01-02 dos65 media boot work
2023-02-16 enclosure
2023-03-04 add software binaries
2023-03-13 convert to supermon
2023-03-20 Boot Code
2023-03-20 FLOPPY Boot Code
2023-03-25 DOS65 Floppy Boot
2023-03-25 DOS65 device cleanup
2023-05-22 add Z80ESP design
2023-06-19 z80 esp
2023-07-15 esp wifi work
2023-07-16 esp MOUSE WORK
2023-07-23 add readme to Z80ESP
2023-08-05 fix tcp bugs
2023-08-06 6809 work
2023-08-11 Z80PROCDMA Development
2023-08-12 Z80ESP Docs
2023-08-14 update PlatformIO dependencies
2023-08-19 testesp work
2023-08-21 esptest work
2023-08-21 Fix serial 2 firmware
2023-09-02 ESP firmware updates
