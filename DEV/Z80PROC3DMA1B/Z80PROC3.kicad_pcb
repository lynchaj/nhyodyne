# Repository lynchaj/nhyodyne

File README.md:

# nhyodyne: A Modular Backplane Computer (MBC)

# Introduction
The purpose of this project is to revisit the design concepts behind my original Z80 SBC (aka test prototype) which has evolved into the SBC V2-005 over several years. Attempt to introduce some new concepts to make the design more modular, flexible, and less expensive. Use low cost prototype PCBs (100x100mm) available for less than $20 including shipping from JLCPCB. Make simple single function boards to implement good program design concepts from Computer Science: high cohesion and low coupling. Maintain as much backward compatibility with latest SBC V2 as possible.

# Overview
The MBC consists of four core boards: Z80 backplane, Z80 processor, Z80 clock, and Z80 ROM. These are sufficient to build a working system of minimum capability. However  the core boards are designed in such a way that they can be individually redesigned and replaced with improved designs and/or customized to suit the builder. It achieves low coupling by implementing a simple bus using off-the-shelf 2×25 2.54mm spaced pin headers and socket strips. The backplane is a replication of a fully buffered Z80 CPU pin out in the same order. Each board has high cohesion by being limited to a single function consisting of only parts specifically related to to perform its task. This lowers builder cost by eliminating unnecessary parts and improves system reliability by having fewer parts to fail. Likewise, if a component or whole board fails it can be replaced without affecting the remaining boards.

# Tools
Open Source tools and software are used to the maximum extend possible to keep costs down for people building the Z80 MBC.  The target software for Z80 MBC is ROMWBW and is supported in the Dev Branch.  All boards are designed using KiCAD version 5 or later and FreeRouting for PCB trace autorouting.  Gerber files are supplied for most boards and can be obtained from JLCPCB or the PCB manufacturer of your choice.

RomWBW Dev Branch  https://github.com/wwarthen/romwbw/tree/dev

KiCAD version 5 or later  https://www.kicad.org/

FreeRouting  https://github.com/freerouting/freerouting

JLCPCB  https://jlcpcb.com/

RpProto https://www.rpproto.com/

# Additional Design Goals
There are several additional design goals for the Z80 MBC.

First, is to ease constraints on the design to allow for some new configurations. Specifically capability to access memory over the bus and configurable memory map holes for external memory.

A second design goal is making all IO devices optional, fully configurable, and limiting IO port addresses to only the minimum necessary. Multiple IO devices can exist in the system simultaneously or not exist as the builder chooses. Lowers cost and improves system reliability by removing unneeded and/or unwanted capabilities.

The third design goal is allowing multiple memory modules with boot enable jumpers to specify boot devices present after CPU reset.

Fourth, adding simple debug features like user LEDs and a switch.

Fifth, implementing a fully buffered Z80 processor with configurable wait state capability and no internal IO or memory devices. Related is each board is also fully buffered to keep bus signals only on the bus with no raw bus signals intruding into the board past the buffers.

Sixth, maintain backwards compatibility to the extent possible (two exceptions so far) to reuse existing SBC software. Target software is current ROMWBW

Seventh, lower build cost by using inexpensive off-the-shelf components and PCBs. All parts come from Jameco or eBay (like bus connectors). Use simple 9vdc 1A unregulated power supply. Keep part count on boards low so they are effectively disposable eliminating the need for sockets and further lowering builder costs. Make non-essential components optionally do-not-populate.

Photo: Wayne Warthen's early version of Z80 MBC with prototype DSKY V3.  From left to right; contains boards Z80BCKPLN1 (underneath), Z80CLOCK, Z80PROC, Z80RAM, Z80ROM, Z80SERIAL, and Z80PPIDE with CF adapter installed.  Z80PPIDE is also connected to DSKY V3 via legacy PPI connector.
DSKY V3 by Dan Werner  https://www.retrobrewcomputers.org/doku.php?id=boards:ecb:dskyng

# Frequently Asked Questions
  What is "nhyodyne"?  The name nyhodyne is completely made up in an attempt to be unique.  It is pronounced like "neodyne".  https://www.howtopronounce.com/neo meaning "new" and https://www.howtopronounce.com/dyne meaning "force"

  Who is the intended audience?  Electronic and retrocomputing hobbyists of all ages and experience.  From brand new beginners to experienced designers, all are welcome.  Help is available on the discussion forum as needed or get in contact with me personally.  The boards are designed with beginners in mind and use common off-the-shelf tools and components.  I try to keep specialized parts to a minimum as well as surface mount devices (SMD) and/or programmable logic devices (GALs, CPLDs, FPGAs).

Where can I get Printed Circuit Boards (PCBs)?  Use the supplied Gerber files and order from JLCPCB or any other manufacturer. I just accept the defaults and they work fine.  You can customize if you want but you should know what you're doing.

I ordered PCBs and now I have extras.  What do I do with them?  Give them away to family and friends!  They make excellent gifts and affordable too!  Don't let the extras sit on a shelf gathering dust.  Share the fun

Can I use these designs in my science fair, school project, etc?  Sure, but please cite your source so others can find this project too.

What if I want to fork my own project based on your work?  It's OK with me and I wish you the best of luck.  I'll be happy to answer questions as best I can and as time allows.

Can these designs be used commercially?  Not really and I'd prefer they be kept for hobbyists because that's they're intended purpose.  If you take these designs partially or in whole commercial you are on your own and accept all associated risk.  These are intended for hobbyist and educational use only.

Why are all the PCBs green?  I like green PCBs and am a bit of a traditionalist from back in the day when PCBs only came in green.  Also it is a good color choice to see the traces underneath and provides good contrast compared to other colors.  That being said, you can make your PCBs any color you like when you order them.

Wow, this is cool!  How do I get involved?  Simple, download the Gerber files and get them built at JLCPCB or whatever PCB manufacturer you prefer.  Order parts and build your boards.  Post your questions on the forum with pictures.

What can I do to support nhyodyne project?  Great question!  What it most needs is YOU so start building your boards right away.  Then tell your friends.  Post on your favorite retrocomputing forums like retro-comp, comp.os.cpm, vogons.org, vintage computer sites, retrobrewcomputers.org, S100computers.com, etc.

Do you accept monetary donations?  Not really, but some people send money and I appreciate their generousity and thank them profusely. However, the truth is I am a senior engineer much closer to retirement than the beginning of my career.  I really enjoy this hobby so much I want to share it with others and make new friends.  If you insist on donations, I will usually graciously accept them but I'd rather you built your own system and tell all your friends about it.

Hey, I've got a great idea for a new board!  How to I make it?  I can help you and depending on your skill level either make it myself for the project or help you make it yourself.   There are people doing both.  I occasionally take requests for new boards although when I make them they are subject to my sense of priority and availability.  In other words, if I make them it will be on my own time and when I am ready.

Any closing thoughts?   Yes, have a great day!  Get out and enjoy your life!  This is a wonderful hobby and I've met the best people -- you will too.  I wish you a long and prosperous life with all the happiness it can bring.  Help someone else along the way.

## KiCad design DEV/Z80PROC3DMA1B/Z80PROC3.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C9, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C22, C23, C24: 0.1u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C8, C10, C21: 10u; CP_Radial_D4.0mm_P2.00mm
D1: POWER; LED_D3.0mm
D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D3: ~{WAIT}; LED_D3.0mm
D4: ~{NMI}; LED_D3.0mm
D5: ~{INT}; LED_D3.0mm
H1, H2: BRACKET; MountingHole_2.2mm_M2_Pad
H3, H4: MountingHole_Pad; MountingHole_2mm
IC1: Z80; PLCC-44_THT-Socket; Manufacturer_Part_Number Z84C00
IC2: DMA; PLCC-44_THT-Socket; Manufacturer_Part_Number Z84C4206PEG; Mouser Part Number 692-Z84C4206PEG
J1: MEMRD; PinHeader_2x06_P2.54mm_Vertical
J2: MEMWR; PinHeader_2x06_P2.54mm_Vertical
J3: IORD; PinHeader_2x06_P2.54mm_Vertical
J4: IOWR; PinHeader_2x06_P2.54mm_Vertical
JP1, JP4: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
NT1, NT2, NT3, NT4: NetTie_2; NetTie-2_SMD_Pad0.5mm
P1: Z80 BUS BACKPLANE; PinHeader_2x25_P2.54mm_Horizontal
P3: EXT INT; PinHeader_2x04_P2.54mm_Horizontal
PB1, PB2, PB3, PB4: TestPoint; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
Q1, Q2, Q3: TestPoint; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
R1, R2, R5: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R8, R9, R10: 1K8; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6, R11, R12: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 10R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RN1, RN2: 4700; R_Array_SIP9
SW1: SW_Push; SW_Tactile_SPST_Angled_PTS645Vx58-2LFS
TestPoint1: ~{I2C_IACK}; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
TestPoint2: ~{I2C_INT}; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
U1: 74LS367; DIP-16_W7.62mm
U2: 74LS07; DIP-14_W7.62mm
U3: GAL16V8; DIP-20_W7.62mm
U4, U5, U7: 74LS244; DIP-20_W7.62mm
U6: 74LS245; DIP-20_W7.62mm
U8: 74LS00; DIP-14_W7.62mm
U9: 74LS164; DIP-14_W7.62mm
U10: 74LS153; DIP-16_W7.62mm
U11: 74LS32; DIP-14_W7.62mm
U12: 74LS148; DIP-16_W7.62mm
U13: 74LS373; DIP-20_W7.62mm
U14: 74LS74
U15: 24LC512; DIP-8_W7.62mm
U16: 74LS77; DIP-14_W7.62mm
U17: 74LS04; DIP-14_W7.62mm
U18: PCF8584; DIP-20_W7.62mm
U19: ATtiny85; DIP-8_W7.62mm
U20: LTC6904_MSOP; MSOP-8_3x3mm_P0.65mm
X1: CXO_DIP8; Oscillator_DIP-8

Connections:
/0WS: J1.2, J2.2, J3.2, J4.2, NT1.2
/1WS: J1.3, J2.3, J3.3, J4.3, U9.3 (Q0)
/2WS: J1.4, J2.4, J3.4, J4.4, U9.4 (Q1)
/3WS: J1.5, J2.5, J3.5, J4.5, U9.5 (Q2)
/4WS: J1.8, J2.8, J3.8, J4.8, U9.6 (Q3)
/5WS: J1.9, J2.9, J3.9, J4.9, U9.10 (Q4)
/6WS: J1.12, J2.12, J3.12, J4.12, U9.11 (Q5)
/7WS: J1.11, J2.11, J3.11, J4.11, U9.12 (Q6)
/8WS: U9.13 (Q7)
/A0: P1.21, U4.18 (1Y0)
/A1: P1.19, U4.16 (1Y1)
/A2: P1.17, U4.14 (1Y2)
/A3: P1.15, U4.12 (1Y3)
/A4: P1.13, U4.3 (2Y0)
/A5: P1.11, U4.5 (2Y1)
/A6: P1.9, U4.7 (2Y2)
/A7: P1.7, U4.9 (2Y3)
/A8: P1.5, U5.18 (1Y0)
/A9: P1.3, U5.16 (1Y1)
/A10: P1.1, U5.14 (1Y2)
/A11: P1.2, U5.12 (1Y3)
/A12: P1.4, U5.3 (2Y0)
/A13: P1.6, U5.5 (2Y1)
/A14: P1.8, U5.7 (2Y2)
/A15: P1.10, U5.9 (2Y3)
/BUSACK: U4.1 (1OE), U4.19 (2OE), U5.1 (1OE), U5.19 (2OE), U7.19 (2OE), U17.4
/CLK: P1.12, RN2.3 (R2), U1.5 (O2a)
/CLKSEL: U14.2 (D), U16.14 (Q0)
/D0: P1.28, U6.18 (B0), U13.2 (O0)
/D1: P1.30, U6.17 (B1), U13.5 (O1)
/D2: P1.24, U6.16 (B2), U13.6 (O2)
/D3: P1.16, U6.15 (B3), U13.9 (O3)
/D4: P1.14, U6.14 (B4), U13.12 (O4)
/D5: P1.18, U6.13 (B5), U13.15 (O5)
/D6: P1.20, U6.12 (B6), U13.16 (O6)
/D7: P1.26, U6.11 (B7), U13.19 (O7)
/I2C_CLK: P1.50, PB2.1, R12.2, U15.6 (SCL), U18.3 (SCL), U19.7 (PB2), U20.3 (SCL)
/I2C_SDA: P1.48, R11.2, U15.5 (SDA), U18.2 (SDA), U19.5 (AREF/PB0), U20.2 (SDA)
/PORT0: U3.16 (IO4), U16.12 (E01)
/PORT1: U3.15 (IO5), U16.3 (E23)
/RDY: U10.7 (Za), U11.2
/READY: U2.13, U11.3
/SPARE1: P1.44
/SPARE6: P1.47
/WS-IORD: J3.1, J3.6, J3.7, J3.10, U10.5 (I1a)
/WS-IOWR: J4.1, J4.6, J4.7, J4.10, U10.3 (I3a)
/WS-MEMRD: J1.1, J1.6, J1.7, J1.10, U10.6 (I0a)
/WS-MEMWR: J2.1, J2.6, J2.7, J2.10, U10.4 (I2a)
/bA0: IC1.34 (A0), IC2.7 (A0), U3.7 (I7), U4.2 (1A0), U18.6 (A0)
/bA1: IC1.35 (A1), IC2.5 (A1), U3.6 (I6), U4.4 (1A1)
/bA2: IC1.36 (A2), IC2.4 (A2), U3.5 (I5), U4.6 (1A2)
/bA3: IC1.37 (A3), IC2.3 (A3), U3.4 (I4), U4.8 (1A3)
/bA4: IC1.38 (A4), IC2.2 (A4), U3.3 (I3), U4.17 (2A0)
/bA5: IC1.39 (A5), IC2.1 (A5), U3.1 (I1/CLK), U4.15 (2A1)
/bA6: IC1.40 (A6), IC2.44 (A6), U3.19 (IO1), U4.13 (2A2)
/bA7: IC1.41 (A7), IC2.43 (A7), U3.18 (IO2), U4.11 (2A3)
/bA8: IC1.42 (A8), IC2.26 (A8), U5.2 (1A0)
/bA9: IC1.43 (A9), IC2.25 (A9), U5.4 (1A1)
/bA10: IC1.44 (A10), IC2.24 (A10), U5.6 (1A2)
/bA11: IC1.1 (A11), IC2.23 (A11), U5.8 (1A3)
/bA12: IC1.2 (A12), IC2.22 (A12), U5.17 (2A0)
/bA13: IC1.3 (A13), IC2.21 (A13), U5.15 (2A1)
/bA14: IC1.4 (A14), IC2.20 (A14), U5.13 (2A2)
/bA15: IC1.5 (A15), IC2.19 (A15), U5.11 (2A3)
/bCLK: IC1.7 (CLK), IC2.8 (CLK), U1.4 (I2), U9.8 (CP), U14.8 (~Q), U14.12 (D), U18.1 (CLK)
/bD0: IC1.16 (D0), IC2.39 (D0), U6.2 (A0), U16.5 (D2), U18.7 (D0)
/bD1: IC1.17 (D1), IC2.38 (D1), U6.3 (A1), U16.6 (D3), U18.8 (D1)
/bD2: IC1.14 (D2), IC2.37 (D2), U6.4 (A2), U16.2 (D1), U18.9 (D2)
/bD3: IC1.9 (D3), IC2.36 (D3), U6.5 (A3), U16.1 (D0), U18.11 (D3)
/bD4: IC1.8 (D4), IC2.35 (D4), U6.6 (A4), U18.12 (D4)
/bD5: IC1.10 (D5), IC2.33 (D5), U6.7 (A5), U18.13 (D5)
/bD6: IC1.11 (D6), IC2.32 (D6), U6.8 (A6), U18.14 (D6)
/bD7: IC1.15 (D7), IC2.31 (D7), U6.9 (A7), U18.15 (D7)
/~BAI: IC1.27 (BUSACK), IC2.16 (~BAI), U3.14 (IO6), U8.12
/~BAO: IC2.15 (~BA0), P1.46, U7.2 (1A0), U17.3
/~BUSACK: P1.35, U7.18 (1Y0)
/~BUSRQ: IC1.29 (BUSRQ), IC2.17 (~BUSREQ), P1.31, RN2.7 (R6), U3.12 (IO8)
/~CS_DMA: IC2.18 (~CE/WAIT), U3.13 (IO7), U8.13
/~CS_I2C: U3.17 (I03), U11.12, U18.17 (~CS)
/~DREQ0: JP3.1 (A), P1.41
/~HALT: P1.36, U7.16 (1Y1)
/~IEO: P1.49, U1.13 (O6b)
/~IM2-INT: U2.9, U11.10, U12.14 (GS)
/~INTA: U8.9, U11.6, U11.9
/~INT: D5.1 (K), IC2.41 (~INT/PULSE), P1.32, RN2.5 (R4), U1.10 (I4), U2.8
/~IORQ: P1.40, R4.2, U7.3 (2Y0)
/~IRQ0: JP2.2 (B), P3.1, RN1.5 (R4), U12.4 (I7)
/~IRQ1: P3.2, RN1.4 (R3), U12.3 (I6)
/~IRQ2: P3.3, RN1.3 (R2), U12.2 (I5)
/~IRQ3: P3.4, RN1.2 (R1), U12.1 (I4)
/~IRQ4: P3.5, RN1.6 (R5), U12.13 (I3)
/~IRQ5: P3.6, RN1.7 (R6), U12.12 (I2)
/~IRQ6: P3.7, RN1.8 (R7), U12.11 (I1)
/~IRQ7: P3.8, RN1.9 (R8), U12.10 (IO)
/~M1: P1.27, U7.12 (1Y3)
/~MREQ: P1.38, R8.2, U7.5 (2Y1)
/~MR: U8.3, U8.5, U9.9 (~MR)
/~NMI: P1.34, RN2.4 (R3), U1.6 (I3), U2.5
/~RD: P1.39, R10.2, U7.9 (2Y3)
/~RESET: P1.29, RN2.2 (R1), U1.2 (I1), U2.10
/~RFSH: P1.25, U7.14 (1Y2)
/~TEND0: P1.45
/~WAIT: D3.1 (K), P1.33, RN2.6 (R5), U1.12 (I5), U2.12
/~WR: P1.37, R9.2, U7.7 (2Y2)
/~bIEO: IC2.40 (IEO), U1.14 (I6)
/~bIORQ: IC1.22 (IOREQ), IC2.11 (~IORQ), RN2.8 (R7), U3.9 (I9), U7.17 (2A0), U8.2, U11.5
/~bM1: IC1.31 (M1), IC2.30 (~M1), U3.8 (I8), U7.8 (1A3), U11.4, U13.11 (LE)
/~bMREQ: IC1.21 (MREQ), IC2.14 (~MREQ), U7.15 (2A1), U8.1, U10.14 (S0)
/~bRD: IC1.23 (RD), IC2.10 (~RD), U7.11 (2A3), U8.10, U10.2 (S1), U18.16 (~RD)
/~bRESET: IC1.30 (RESET), IC2.12 (~RESET), U1.3 (O1a), U3.2 (I2), U18.19 (~RST), U19.1 (~RESET/PB5)
/~bWAIT: IC1.28 (WAIT), U1.11 (O5b), U3.11 (I10/~OE)
/~bWR: IC1.26 (WR), IC2.9 (~WR), U7.13 (2A2), U11.13
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, D1.1 (K), H1.1, H2.1, IC1.33 (GND), IC2.34 (GND), JP1.3 (B), JP4.1 (A), NT2.1, P1.23, P1.43, SW1.2, U1.1 (OEa), U1.8 (GND), U1.15 (OEb), U2.7 (GND), U3.10 (GND), U4.10 (GND), U5.10 (GND), U6.10 (GND), U7.1 (1OE), U7.10 (GND), U8.7 (GND), U9.7 (GND), U10.1 (Ea), U10.8 (GND), U11.7 (GND), U12.5 (EI), U12.8 (GND), U13.10 (GND), U14.7 (GND), U15.1 (A0), U15.4 (GND), U15.7 (WP), U16.11 (GND), U17.7 (GND), U18.10 (VSS), U19.4 (GND), U20.1 (GND), X1.4 (GND)
unnamed: D1.2 (A), R5.2
unnamed: C10.1, D2.2 (A), R6.2, R7.2, U2.11
unnamed: D3.2 (A), R3.1
unnamed: D4.2 (A), R1.1
unnamed: D4.1 (K), U2.6
unnamed: D5.2 (A), R2.1
unnamed: IC1.20 (HALT), U7.4 (1A1)
unnamed: IC1.18 (INT), U1.9 (O4a)
unnamed: IC1.19 (NMI), U1.7 (O3a)
unnamed: IC1.32 (RFSH), U7.6 (1A2), U8.4
unnamed: IC2.42 (IEI), NT4.2
unnamed: IC2.27 (RDY), JP3.3 (B)
unnamed: JP1.2 (C), U15.2 (A1), U15.3 (A2)
unnamed: JP3.2 (C), NT3.2
unnamed: R7.1, SW1.1
unnamed: U6.1 (A->B), U17.6
unnamed: U6.19 (CE), U8.11
unnamed: U8.6, U11.1
unnamed: U12.9 (S0), U13.4 (D1)
unnamed: U12.7 (S1), U13.7 (D2)
unnamed: U12.6 (S2), U13.8 (D3)
unnamed: NT2.2, U13.3 (D0), U13.13 (D4), U13.14 (D5), U13.17 (D6), U13.18 (D7)
unnamed: U11.8, U13.1 (OE)
unnamed: U14.3 (C), U17.1, U20.6 (CLK), X1.5 (OUT)
unnamed: U14.5 (Q), U14.13 (~R)
unnamed: U14.4 (~S), U14.9 (Q)
unnamed: U14.11 (C), U17.2
unnamed: Q1.1, U16.13 (Q1)
unnamed: Q2.1, U16.9 (Q2)
unnamed: Q3.1, U16.8 (Q3)
unnamed: U8.8, U17.5
unnamed: TestPoint1.1, U18.4 (~IACK)
unnamed: TestPoint2.1, U18.5 (~INT)
unnamed: U11.11, U18.18 (~WR)
unnamed: PB3.1, U19.2 (XTAL1/PB3)
unnamed: PB4.1, U19.3 (XTAL2/PB4)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, D2.1 (K), IC1.13 (+5V), IC2.13 (VCC), JP1.1 (A), JP4.3 (B), NT1.1, NT3.1, NT4.1, P1.22, P1.42, R1.2, R2.2, R3.2, R4.1, R5.1, R6.1, R8.1, R9.1, R10.1, R11.1, R12.1, RN1.1 (common), RN2.1 (common), U1.16 (VCC), U2.14 (VCC), U3.20 (VCC), U4.20 (VCC), U5.20 (VCC), U6.20 (VCC), U7.20 (VCC), U8.14 (VCC), U9.1 (DSA), U9.2 (DSB), U9.14 (VCC), U10.16 (VCC), U11.14 (VCC), U12.16 (VCC), U13.20 (VCC), U14.1 (~R), U14.10 (~S), U14.14 (VCC), U15.8 (VCC), U16.4 (VCC), U17.14 (VCC), U18.20 (VDD), U19.8 (VCC), U20.7 (OE), U20.8 (VCC), X1.1 (EN), X1.8 (Vcc)

Notes on the sheet:
IEO is an output so the last device does not need to be terminated
Spare Gates
BUSAK
IEI
+5v
DEV
BAO
The following input signals from the backplane are permanently buffered: /RESET /NMI /INT /WAIT
DMA
IEO
The following locally generated signals on the board reenter through the back plane: /RESET from the reset button /INT from the DMA chip
Note: Bus connector is mirror image of Z80 CPU pin out to mate to backplane whose connectors reflect Z80 CPU pin out.
BAI
The following output signals are buffered and permanently driven to the backplane: /BUSACK /HALT /RFRSH /M1 CLK
Wait State Generator Circuit
Interrupt Mode 2 (IM2) Circuit
Tri-state address, data, & control bus during DMA
BUFFER
The following signals have 4K7 pullups on backplane side: CLK /NMI /INT /WAIT /BUSRQ The following signals have 1K8 pullups on backplane side: /IORQ /MREQ /WR /RD
CPU

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