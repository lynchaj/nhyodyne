# Repository lynchaj/nhyodyne (continued)

## KiCad design DEV/Z80PROC3DMA1B/Z80PROC3.kicad_pcb (continued)

Board: 2 copper layers, 100.0 x 100.0 mm, 92 parts (8 on the bottom side), 147 nets.

## KiCad design Z80ESP/HARDWARE/Z80ESP.kicad_pcb

File Z80ESP/README.md (part):

# ESP32 Multi IO
The Nhyodyne ESP32 board provides the following functions for your Nhyodyne computer
* ANSI Console
* Graphics
* Sprites
* Sound
* Dual USB Serial Support
* WiFi
* Keyboard
* Mouse

This board relies heavily on the FabGL library from Fabrizio Di Vittorio.   More information can be found [HERE](http://www.fabglib.org/)

# ESP32 BOM
Qty|Reference(s)|Value|Notes
---|------------|-----|-----
12|C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C13, C14|0.1uF
3|C11, C12, C16|10uF
1|C15|100nf
1|D2|LED
2|D3, D6|1N4001
1|J3|Pin Header, right angle 1x2
1|J4|Pin Header, right angle 1x3
1|J5|Pin Header, right angle 1x3
1|J6|DB15 Female High Density PCB VGA Connector
1|J7|Pin Header, right angle 2x5
1|P2|Pin Header Right Angle 2x25
4|R1, R3, R14, R15|120ohm
1|R2|470ohm
2|R4, R6|2Kohm
2|R5, R13|1Kohm
3|R7, R9, R11|400ohm
3|R8, R10, R12|800ohm
1|R16|270ohm
1|R17|150ohm
1|RR1|10Kohm, networked, 9 pin, 8 resistor
1|RR2|1Kohm, networked, 9 pin, 8 resistor
1|SW1|8 position DIP switch
1|U1|74LS04
2|U2, U4|74LS244
1|U3|74LS245
3|U5, U6, U14|74LS32
2|U7, U9|74HC595
2|U8, U11|74HC165
1|U10|74LS688
2|U12, U13|ESP-WROOM-32 Dev Module|Such As: https://www.amazon.com/ESP-WROOM-32-Development-Microcontroller-Integrated-Compatible/dp/B08D5ZD528
1|U15|74LS244
1|U16|74LS07

# ESP32 Firmware Installation
The firmware for this board requires that platformio be installed on your system.

To install platformio core for your operating system see the directions [HERE](https://platformio.org/install/cli).  
Make sure you follow the additional directions to install the shell commands.

On linux systems it may be necessary to update permissions for the device that is autocreated for the ESP32. [More details](https://docs.platformio.org/en/latest/core/installation/udev-rules.html)  
Once platformio is properly setup on your system, you should be able to build and deploy the firmware to the ESP32.  

## To build and install the ESP firmware:
Take the ESP32 device you have designated as ESP0 and with it NOT INSTALLED in the nhyodyne card, plug it into your computer via USB.
change directory to the ESP0Firmware folder on your PC and from the operating system prompt type
```
pio run -t upload
```

Over the next couple of minutes you should see the build and upload process
something like this:

```
dwerner@lserver02:/lserver03/fileserv/Development/Vintage/Projects/nhyodyne/Z80ESP/ESP0Firmware$ pio run -t upload
Processing esp32dev (platform: espressif32; board: esp32dev; framework: arduino)
-----------------------------------------------------------------------------------------------------------------------
Verbose mode can be enabled via `-v, --verbose` option
CONFIGURATION: https://docs.platformio.org/page/boards/espressif32/esp32dev.html
PLATFORM: Espressif 32 (6.3.2) > Espressif ESP32 Dev Module
HARDWARE: ESP32 240MHz, 320KB RAM, 4MB Flash
DEBUG: Current (cmsis-dap) External (cmsis-dap, esp-bridge, esp-prog, iot-bus-jtag, jlink, minimodule, olimex-arm-usb-ocd, olimex-arm-usb-ocd-h, olimex-arm-usb-tiny-h, olimex-jtag-tiny, tumpa)
PACKAGES:
 - framework-arduinoespressif32 @ 3.20009.0 (2.0.9)
 - tool-esptoolpy @ 1.40501.0 (4.5.1)
 - tool-mkfatfs @ 2.0.1
 - tool-mklittlefs @ 1.203.210628 (2.3)
 - tool-mkspiffs @ 2.230.0 (2.30)
 - toolchain-xtensa-esp32 @ 8.4.0+2021r2-patch5
LDF: Library Dependency Finder -> https://bit.ly/configure-pio-ldf
LDF Modes: Finder ~ deep+, Compatibility ~ soft
Found 34 compatible libraries
Scanning dependencies...
Dependency Graph
|-- FabGL @ 1.0.9
|-- SPI @ 2.0.0
|-- Preferences @ 2.0.0
Building in release mode
Retrieving maximum program size .pio/build/esp32dev/firmware.elf
Checking size .pio/build/esp32dev/firmware.elf
Advanced Memory Usage is available via "PlatformIO Home > Project Inspect"
RAM:   [=         ]   9.3% (used 30632 bytes from 327680 bytes)
Flash: [=====     ]  46.4% (used 608561 bytes from 1310720 bytes)
Configuring upload protocol...
AVAILABLE: cmsis-dap, esp-bridge, esp-prog, espota, esptool, iot-bus-jtag, jlink, minimodule, olimex-arm-usb-ocd, olimex-arm-usb-ocd-h, olimex-arm-usb-tiny-h, olimex-jtag-tiny, tumpa
CURRENT: upload_protocol = esptool
Looking for upload port...
Auto-detected: /dev/ttyUSB0
Uploading .pio/build/esp32dev/firmware.bin
esptool.py v4.5.1
Serial port /dev/ttyUSB0
Connecting.....
Chip is ESP32-D0WD-V3 (revision v3.0)
Features: WiFi, BT, Dual Core, 240MHz, VRef calibration in efuse, Coding Scheme None
Crystal is 40MHz
MAC: 08:b6:1f:33:39:fc
Uploading stub...
Running stub...
Stub running...
Changing baud rate to 460800
Changed.
Configuring flash size...
Flash will be erased from 0x00001000 to 0x00005fff...
Flash will be erased from 0x00008000 to 0x00008fff...
Flash will be erased from 0x0000e000 to 0x0000ffff...
Flash will be erased from 0x00010000 to 0x000a4fff...
Compressed 17488 bytes to 12168...
Writing at 0x00001000... (100 %)
Wrote 17488 bytes (12168 compressed) at 0x00001000 in 0.5 seconds (effective 287.3 kbit/s)...
Hash of data verified.
Compressed 3072 bytes to 146...
Writing at 0x00008000... (100 %)
Wrote 3072 bytes (146 compressed) at 0x00008000 in 0.0 seconds (effective 571.2 kbit/s)...
Hash of data verified.
Compressed 8192 bytes to 47...
Writing at 0x0000e000... (100 %)
Wrote 8192 bytes (47 compressed) at 0x0000e000 in 0.1 seconds (effective 829.3 kbit/s)...
Hash of data verified.
Compressed 608928 bytes to 309667...
Writing at 0x00010000... (5 %)
Writing at 0x00020854... (10 %)
Writing at 0x0002f631... (15 %)
Writing at 0x0003b66a... (21 %)
Writing at 0x0004b725... (26 %)
Writing at 0x00050794... (31 %)
Writing at 0x00056585... (36 %)
Writing at 0x0005c2fd... (42 %)
Writing at 0x0006271e... (47 %)
Writing at 0x000684b2... (52 %)
Writing at 0x0006dceb... (57 %)
Writing at 0x00073098... (63 %)
Writing at 0x0007864e... (68 %)
Writing at 0x0007de33... (73 %)
Writing at 0x0008412b... (78 %)
Writing at 0x0008c053... (84 %)
Writing at 0x00094cba... (89 %)
Writing at 0x0009a559... (94 %)
Writing at 0x0009f9b7... (100 %)
Wrote 608928 bytes (309667 compressed) at 0x00010000 in 8.0 seconds (effective 606.6 kbit/s)...
Hash of data verified.

Leaving...
Hard resetting via RTS pin...
============================================ [SUCCESS] Took 22.49 seconds ============================================
```

Once this is done you can install ESP0 into U12 on your nhyodyne board.  Then repeat the process for the ESP1 and install into U13.

# ESP32 Communication Protocol

The ESP32 board communicates with your system via 3 ports, two IO ports and one status port.

The default configuration sets the base IO to $9C.  IO Communication with ESP0 is at base port, ESP1 is at base port +1 and the status register is at base port +2.

```
ESPBASE         EQU $9C         ; Base Port
ESP0:           EQU ESPBASE     ; ESP0 IO PORT

ESP1:           EQU ESPBASE+1   ; ESP1 IO PORT

ESP_STATUS:     EQU ESPBASE+2   ; ESP  STATUS PORT
                                ; MSB XX XX S S S S S
                                ;           | | | | |- ESP0 READY_OUTPUT
                                ;           | | | |--- ESP0 BUSY
                                ;           | | |----- ESP0 SPARE (unused)
                                ;           | |------- ESP1 READY_OUTPUT
                                ;           |--------- ESP1 BUSY
```

The communication process is fairly straight forward.  Upon reset, the ESP will initialize, set BUSY and READY_OUTPUT to low and wait for an opcode.

To send an opcode or data to the ESP:

* wait for ESPx BUSY bit to go low (a timeout is suggested)
* write the opcode or data to the ESPx IO port
* it is a best practice to wait for ESPx BUSY bit to go high then low (a timeout is suggested) before sending the next byte

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C13, C14: 0.1µF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C11, C12, C16: 10µF; CP_Radial_D5.0mm_P2.50mm
C15: 100nf; C_Disc_D5.0mm_W2.5mm_P5.00mm
D2: LED; LED_D3.0mm
D3, D6: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2: BRACKET; MountingHole_2.2mm_M2_Pad
J3: AUDIO OUT; PinHeader_1x02_P2.54mm_Horizontal
J4: ESP_SERIAL_1; PinHeader_1x03_P2.54mm_Horizontal
J5: ESP_SERIAL_0; PinHeader_1x03_P2.54mm_Vertical
J6: VGA; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03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
J7: KEYBOARD AND MOUSE; PinHeader_2x05_P2.54mm_Horizontal
P2: Z80 BUS BACKPLANE; PinHeader_2x25_P2.54mm_Horizontal
R1, R3, R14, R15: 120Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 470Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R6: 2KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R13: 1KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R9, R11: 400Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R10, R12: 800Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R16: 270Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R17: 150Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RR1: 10KΩ; R_Array_SIP9
RR2: 1KΩ; R_Array_SIP9
SW1: IO PORT ADDR; SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm
U1: 74LS04; DIP-14_W7.62mm
U2, U4, U15: 74LS244; DIP-20_W7.62mm
U3: 74LS245; DIP-20_W7.62mm
U5, U6, U14: 74LS32; DIP-14_W7.62mm
U7, U9: 74HC595; DIP-16_W7.62mm
U8, U11: 74HC165; DIP-16_W7.62mm
U10: 74LS688; DIP-20_W7.62mm
U12, U13: ESP32_MODULE
U16: 74LS07; DIP-14_W7.62mm

Connections:
+3.3V: R4.2, R5.2, R6.2, R13.2, RR2.1 (COM), U12.1 (RESET), U12.16 (3.3V), U13.1 (RESET), U13.16 (3.3V)
/bA2: U2.14 (O2a), U10.6 (P2)
/bA3: U2.12 (O3a), U10.8 (P3)
/bA4: U2.9 (O0b), U10.11 (P4)
/bA5: U2.7 (O1b), U10.13 (P5)
/bA6: U2.5 (O2b), U10.15 (P6)
/bA7: U2.3 (O3b), U10.17 (P7)
/b~IORQ: U4.9 (O0b), U10.1 (G)
/b~M1: U4.7 (O1b), U10.2 (P0), U10.4 (P1)
/b~WR: U4.5 (O2b), U6.9
A0: P2.21, U2.2 (I0a)
A1: P2.19, U2.4 (I1a)
A2: P2.17, U2.6 (I2a)
A3: P2.15, U2.8 (I3a)
A4: P2.13, U2.11 (I0b)
A5: P2.11, U2.13 (I1b)
A6: P2.9, U2.15 (I2b)
A7: P2.7, U2.17 (I3b)
A8: P2.5
A9: P2.3
A10: P2.1
A11: P2.2
A12: P2.4
A13: P2.6
A14: P2.8
A15: P2.10
AUDIO: R16.1, U12.8 (GPIO25)
CLK: P2.12
D0: P2.28, U3.2 (A0)
D1: P2.30, U3.3 (A1)
D2: P2.24, U3.4 (A2)
D3: P2.16, U3.5 (A3)
D4: P2.14, U3.6 (A4)
D5: P2.18, U3.7 (A5)
D6: P2.20, U3.8 (A6)
D7: P2.26, U3.9 (A7)
ESP0_BUSY: U12.11 (GPIO14), U15.4 (I1a)
ESP0_IN: RR2.3, U12.22 (GPIO17), U16.12
ESP0_INCLK: U8.2 (CP), U12.10 (GPIO27)
ESP0_OUT: U7.14 (SER), U12.21 (GPIO16)
ESP0_OUTCLK: U7.11 (SRCLK), U7.12 (RCLK), U12.9 (GPIO26)
ESP0_RDYO: U12.12 (GPIO12), U15.2 (I0a)
ESP0_SPAREO: U12.19 (GPIO2), U15.6 (I2a)
ESP1_BUSY: U13.24 (GPIO18), U15.11 (I0b)
ESP1_IN: RR2.8, U13.22 (GPIO17), U16.10
ESP1_INCLK: U11.2 (CP), U13.25 (GPIO19)
ESP1_OUT: U9.14 (SER), U13.21 (GPIO16)
ESP1_OUTCLK: U9.11 (SRCLK), U9.12 (RCLK), U13.26 (GPIO21)
ESP1_RDYO: U13.23 (GPIO5), U15.8 (I3a)
KBDCLK: R14.2, U12.7 (GPIO33)
KBDDAT: R15.2, U12.6 (GPIO32)
MSECLK: R3.1, U13.7 (GPIO33)
MSEDAT: R1.1, U13.6 (GPIO32)
unnamed: C15.1, C16.1, R16.2, R17.1
unnamed: C16.2, J3.2
unnamed: D2.2 (A), R2.1
unnamed: D3.1 (K), U12.15 (VIN)
unnamed: D6.1 (K), U13.15 (VIN)
unnamed: J6.1, R7.2, R8.2
unnamed: J6.2, R9.2, R10.2
unnamed: J6.3, R11.2, R12.2
unnamed: J7.2, R13.1, R14.1
unnamed: J7.4, R6.1, R15.1
unnamed: J7.7, R1.2, R4.1
unnamed: J7.9, R3.2, R5.1
unnamed: RR1.2, U10.3 (R0)
unnamed: RR1.3, U10.5 (R1)
unnamed: RR1.4, SW1.11, U10.7 (R2)
unnamed: RR1.5, SW1.12, U10.9 (R3)
unnamed: RR1.6, SW1.13, U10.12 (R4)
unnamed: RR1.7, SW1.14, U10.14 (R5)
unnamed: RR1.8, SW1.15, U10.16 (R6)
unnamed: RR1.9, SW1.16, U10.18 (R7)
unnamed: U1.2, U5.1
unnamed: U1.4, U5.12
unnamed: U1.12, U14.1
unnamed: U6.4, U6.8
unnamed: U6.2, U6.11
unnamed: U11.9 (Q7), U16.11
unnamed: U14.3, U14.5
unnamed: U14.6, U15.1 (OEa), U15.19 (OEb)
unnamed: U5.6, U16.1
unnamed: U5.3, U16.3
unnamed: U5.8, U16.5
unnamed: U5.11, U16.9
unnamed: U8.9 (Q7), U16.13
RX: J5.1, U12.27 (GPIO3)
RX1: J4.1, U13.27 (GPIO3)
SPARE0: P2.42
SPARE1: P2.44
SPARE2: P2.46
SPARE3: P2.48
SPARE4: P2.50
SPARE5: P2.49
SPARE6: P2.47
SPARE7: P2.45
SPARE8: P2.43
SPARE9: P2.41
TX: J5.3, U12.28 (GPIO1)
TX1: J4.3, U13.28 (GPIO1)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, D3.2 (A), D6.2 (A), J7.5, J7.6, P2.22, R2.2, RR1.1 (COM), U1.14 (VCC), U2.20 (VCC), U3.20 (VCC), U4.20 (VCC), U5.14 (VCC), U6.14 (VCC), U7.10 (~SRCLR), U7.16 (VCC), U8.16 (VCC), U9.10 (~SRCLR), U9.16 (VCC), U10.20 (VCC), U11.16 (VCC), U14.14 (VCC), U15.20 (VCC), U16.14 (VCC)
VGA_B0: R12.1, U12.20 (GPIO4)
VGA_B1: R11.1, U12.23 (GPIO5)
VGA_G0: R10.1, U12.24 (GPIO18)
VGA_G1: R9.1, U12.25 (GPIO19)
VGA_HSYNC: J6.13, U12.30 (GPIO23)
VGA_R0: R8.1, U12.26 (GPIO21)
VGA_R1: R7.1, U12.29 (GPIO22)
VGA_VSYNC: J6.14, U12.18 (GPIO15)
bA0: U1.1, U1.3, U2.18 (O0a), U5.5, U5.9
bA1: U1.13, U2.16 (O1a), U6.1, U6.5
bD0: U3.18 (B0), U7.15 (QA), U8.11 (D0), U9.15 (QA), U11.11 (D0), U15.18 (O0a)
bD1: U3.17 (B1), U7.1 (QB), U8.12 (D1), U9.1 (QB), U11.12 (D1), U15.16 (O1a)
bD2: U3.16 (B2), U7.2 (QC), U8.13 (D2), U9.2 (QC), U11.13 (D2), U15.14 (O2a)
bD3: U3.15 (B3), U7.3 (QD), U8.14 (D3), U9.3 (QD), U11.14 (D3), U15.12 (O3a)
bD4: U3.14 (B4), U7.4 (QE), U8.3 (D4), U9.4 (QE), U11.3 (D4), U15.9 (O0b)
bD5: U3.13 (B5), U7.5 (QF), U8.4 (D5), U9.5 (QF), U11.4 (D5), U15.7 (O1b)
bD6: U3.12 (B6), U7.6 (QG), U8.5 (D6), U9.6 (QG), U11.5 (D6), U15.5 (O2b)
bD7: U3.11 (B7), U7.7 (QH), U8.6 (D7), U9.7 (QH), U11.6 (D7), U15.3 (O3b)
b~RD: U4.3 (O3b), U6.12, U14.4
b~RESET: U4.18 (O0a)
~BUSACK: P2.35
~BUSRQ: P2.31
~CS_ESP: U3.19 (CE), U6.10, U6.13, U10.19 (P=R), U14.2
~ESP0_RD: RR2.6, U7.13 (~OE), U12.13 (GPIO13), U16.6
~ESP0_WR: RR2.4, U8.1 (~PL), U12.2 (GPIO36), U16.2
~ESP1_RD: RR2.7, U9.13 (~OE), U13.29 (GPIO22), U16.8
~ESP_RD: U5.10, U5.13, U6.3
~ESP_WR: U5.2, U5.4, U6.6
~HALT: P2.36
~INT: P2.32
~IORQ: P2.40, U4.11 (I0b)
~M1: P2.27, U4.13 (I1b)
~MREQ: P2.38
~NMI: P2.34
~RD: P2.39, U3.1 (A->B), U4.17 (I3b)
~RESET: P2.29, U4.2 (I0a)
~RFSH: P2.25
~WAIT: P2.33
~WR: P2.37, U4.15 (I2b)

Notes on the sheet:
Note: Buffers and Transceivers respond to IO and MEM cycles
SET IO PORT
Note: IO Address Port $9C-$9F S1=off - A7 (high) S2=on - A6 (low) S3=on - A5 (low) S4=off - A4 (high) S5=off - A3 (high) S6=off - A2 (high) S7=off - A1 (no effect) S8=x - A0 (no effect)
Note: Inhibit Board Operation During Interrupts ~{M1} = low, ~{IORQ} = low
Z80 BUS INTERFACE
Note: Bus connector is mirror image of Z80 CPU pin out to mate to backplane whose connectors reflect Z80 CPU pin out.
IO SELECTION CIRCUIT
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

Board: 2 copper layers, 100.0 x 115.0 mm, 63 parts (0 on the bottom side), 114 nets.

File Z80ESP/HARDWARE/Z80ESP_bom.csv:

Qty,Reference(s),Value,
12,C1` C2` C3` C4` C5` C6` C7` C8` C9` C10` C13` C14,0.1uF,
3,C11` C12` C16,10uF,
1,C15,100nf,
1,D2,LED,
2,D3` D6,1N4001,
1,J3,Pin Header` right angle 1x2,
1,J4,Pin Header` right angle 1x3,
1,J5,Pin Header` right angle 1x3,
1,J6,DB15 Female High Density PCB VGA Connector,
1,J7,Pin Header` right angle 2x5,
1,P2,Pin Header Right Angle 2x25,
4,R1` R3` R14` R15,120ohm,
1,R2,470ohm,
2,R4` R6,2Kohm,
2,R5` R13,1Kohm,
3,R7` R9` R11,400ohm,
3,R8` R10` R12,800ohm,
1,R16,270ohm,
1,R17,150ohm,
1,RR1,10Kohm` networked` 9 pin` 8 resistor ,
1,RR2,1Kohm` networked` 9 pin` 8 resistor,
1,SW1,8 position DIP switch,
1,U1,74LS04,
2,U2` U4,74LS244,
1,U3,74LS245,
3,U5` U6` U14,74LS32,
2,U7` U9,74HC595,
2,U8` U11,74HC165,
1,U10,74LS688,
2,U12` U13,ESP-WROOM-32 Dev Module,Such As: https://www.amazon.com/ESP-WROOM-32-Development-Microcontrol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
1,U15,74LS244,
1,U16,74LS07,
