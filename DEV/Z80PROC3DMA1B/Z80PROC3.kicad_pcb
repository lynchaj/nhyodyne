# Repository lynchaj/nhyodyne (continued)

## KiCad design 6809PROC/hardware/Z806809.kicad_pcb

File 6809PROC/README.md (part):

# MBC6809
6809 processor board (hardware and software) for the Nhyodyne computer system

# Bugs
* I AM SURE THERE ARE SOME . . . .

# JUMPER SETTINGS
## General
        J1 - Enable
                1&2 Only CPU
                2&3 Secondary CPU

        J2 - Clock Divider
                1&2 CLK/2
                3&4 CLK/4
                5&6 CLK/8
                7&8 CLK/16
                9&10 CLK

        J4 - Reset
                1&2 Only CPU
                2&3 Secondary CPU

        JP1 - External Reset Switch

        SW1 - IO Page select
                This maps the IO addresses $00-$FF into the 6809 memory space.  Note that
                the 6809 has address line A15 inverted in order to maintain compatibility
                with the Nhyodyne ROM and RAM cards.   Therefore the MSB (SW8) is inverted.  Most applications for this board expect an IO page of $FE ($FE00-$FEFF).Leading to a default setting of:
                1-on
                2-off
                3-off
                4-off
                5-off
                6-off
                7-off
                8-on

        SW2 - Reset

        SW2 - 6809 toggle address
                This setting sets the IO port that toggles the 6809 in and out of control when it is a secondary CPU.  When it is the only CPU in the system this setting has no effect. Most test applications for this board expect an IO address of $F0.   Reading this IO port will toggle the 6809 active/inactive.
                Leading to a default setting of:
                1-on
                2-on
                3-on
                4-on
                5-off
                6-off
                7-off
                8-off

# BOM

Qty|Reference(s)|Value
--- | --- | ---
5|C1, C14, C15, C16, C17|10µf electrolytic
12|C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13|0.1µf
1|D1|Device:LED
1|D2|Device:LED
1|D3|Device:LED
1|D4|Device:LED
1|D5|Device:LED
1|D6|Device:LED
1|D7|1N4148
1|J1|Connecto 02x04 Male Right Angle
1|J2|Connector 01x03  Male Right Angle
1|J3|Connector 01x03  Male Right Angle
1|J4|Connector 02x25  Male Right Angle
1|JP1|Jumper  01x02 Male Right Angle
6|R1, R2, R3, R4, R6, R7|470 ohm
1|R5|10 ohm
1|R8|10K ohm
1|RN1|4700 ohm Network 9
2|RN2, RN4|1K ohm Network 8
1|RN3|1k ohm Network 9
1|RN5|2.2k ohm Network 9
1|SW1|Switch:SW_DIP_x08
1|SW2|Switch:SW_DIP_x08
1|SW3|Switch:SW_Push
1|U1|74LS93
3|U2, U8, U10|74LS244
1|U3|74LS04
2|U4, U7|74LS688
1|U5|74LS245
1|U6|MC6809 (68B09 Preferred)
1|U9|74LS00
1|U11|74LS74
1|U12|74LS07

# SOFTWARE

### MONITOR
This is a simple monitor program, see the "monitor" section of this document for usage instructions. "Monitor" requires that the UART is properly initialized.

It assumes that the 6809 board is set for IOPage $FE.
        * remember that bit A15 is inverted on the board

If the SBC is the only CPU in the system, ensure that jumpers J1 and J4 are set for 1&2, then burn monitor.hex into EPROM. (note that this monitor does not initialize the UART yet, so this is broken at the moment)

If the SBC is secondary to a Z80, the monitor.com file can be run from CP/M or the monitor.hex file can be loaded from the monitor. Ensure that jumpers J1 and J4 are set for 2&3, the 6809 toggle IO address is set for $F0 and the 6809 board is set for IOPage $FE.
        * remember that bit A15 is inverted on the board

To run from the MBC Z80 monitor

first set the MPCL to allow RAM in the low bank
```
>O 7C 80
>O 78 80
```
Then load the .HEX file.
```
>L
```

Finally transfer control to the 6809 by reading the toggle register
```
>I F0
```

### SCREAM
This is a quick program that can be put on a ROM to test the 6809 board. It will output a continuous stream of "A"s from the UART. It does not require the stack to be available and is pretty much the simplest code imaginable. :)

It assumes that the 6809 board is set for IOPage $FE.
        * remember that bit A15 is inverted on the board

If the SBC is the only CPU in the system, ensure that jumpers J1 and J4 are set for 1&2, then burn scream.hex into EPROM.  (note that this monitor does not initialize the UART yet, so this is broken at the moment)

If the SBC is secondary to a Z80, the scrm.com file can be run from CP/M or the scream.hex file can be loaded from the monitor. Ensure that jumpers J1 and J4 are set for 2&3, the 6809 toggle IO address is set for $F0 and the 6809 board is set for IOPage $FE.
        * remember that bit A15 is inverted on the board

To run from the MBC Z80 monitor

first set the MPCL to allow RAM in the low bank
```
>O 7C 80
>O 78 80
```
Then load the .HEX file.
```
>L
```

Finally transfer control to the 6809 by reading the toggle register
```
>I F0
```

The '09 should reset and run this program

### MONITOR Program

Monitor is a simple machine language monitor that will allow you to view and manipulate the 6809 operating environment.

Monitor Supports the following Commands:

```
	* D -  XXXX YYYY - Dump memory from XXXX to YYYY
        * L - Load a S19 file into RAM
       	* M XXXX YY  - update the ram at XXXX with value YY
        * G XXXX - Execute program at XXXX
        * P - PRINT CONTENTS OF STACK
```

### FLEX09 OPERATING SYSTEM

MEMORY MAP:

```
 C000  -------
          I     System Stack
 C080  -------
          I     Input Buffer
 C100  -------
          I
          I     Utility Area
          I
 C400  -------  Startup Code
          I
          I
 C700  -------
          I     Printer Spooler Stub
 C71C  -------
          I     Open Space
          I
 C840  -------
          I
          I     System/User FCB
          I
 C980  -------
          I
          I     System I/O FCB's
          I     (FLEX Initialize at CA00)
          I
 CC00  -------
          I
          I     Flex CCP
          I
 CD00  -------
          I
          I
          I     Disk Operating System
          I
          I
 D3E1  -------
          I     Driver Vector Table
                D3E1 ADDDEV      * add an IRQ handler to table
                D3E3 DELDEV      * delete an IRQ handler from table
                D3E5 INCHNE      * INPUT CHARACTER W/O ECHO
                D3E7 IHNDLR      * IRQ INTERRUPT HANDLER
                D3E9 SWIVEC      * SWI3 VECTOR LOCATION
                D3EB IRQVEC      * IRQ VECTOR LOCATION
                D3ED TMOFF       * TIMER OFF ROUTINE
                D3EF TMON        * TIMER ON ROUTINE
                D3F1 TMINT       * TIMER INITIALIZATION
                D3F3 MONITR      * MONITOR ENTRY ADDRESS
                D3F5 TINIT       * TERMINAL INITIALIZATION
                D3F7 STAT        * CHECK TERMINAL STATUS
                D3F9 VOUTCH      * OUTPUT CHARACTER
                D3FB VINCH       * INPUT CHARACTER W/ ECHO
          I
 D400  -------
          I
          I
          I     File Management-System
          I
          I
          I
 DE00  -------
          I     DISK DRIVER ROUTINE JUMP TABLE
                DE00 READ      Read a single sector
                DE03 WRITE     Write a single sector
                DE06 VERIFY    Verify last sector written
                DE09 RESTORE   Restore head to track #0
                DE0C DRIVE     Select the specified drive
                DE0F CHKRDY    Check for drive ready
                DE12 QUICK     Quick check for drive ready
                DE15 INIT      Driver initialize (cold start)
                DE18 WARM      Driver initialize (warm start)
                DE1B SEEK      Seek to specified track
          I
          I     Disk Drivers
          I
 FE00  -------
          I    I/O Area
 FF00  -------
          I    Work RAM
 FFEF  -------
                FFF0    RESERVED
                FFF2    SWI3 VECTOR
                FFF4    SWI2 VECTOR
                FFF6    FIRQ VECTOR
                FFF8    IRQ VECTOR
                FFFA    SWI VECTOR
                FFFC    NMI VECTOR
                FFFE    RESET VECTOR
 FFFF  -------
```

### FLEX09 OPERATING SYSTEM TODO LIST

Parts:
C1, C14, C15, C16, C17: 10µf; CP_Radial_D4.0mm_P2.00mm
C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13: 0.1µf; C_Disc_D7.5mm_W2.5mm_P5.00mm
D1: POWER; LED_D3.0mm
D2: IR; LED_D3.0mm
D3: MR; LED_D3.0mm
D4: INT; LED_D3.0mm
D5: NMI; LED_D3.0mm
D6: 6809; LED_D3.0mm
D7: 1N4148; D_A-405_P7.62mm_Horizontal
J1: Clock Speed; PinHeader_2x04_P2.54mm_Horizontal
J2: 6809 RESET; PinHeader_1x03_P2.54mm_Horizontal
J3: 6809 ONLY; PinHeader_1x03_P2.54mm_Horizontal
J4: MBC Bus Connector; PinHeader_2x25_P2.54mm_Horizontal
JP1: RESET; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R4, R6, R7: 470Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 10Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8: 10KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RN1: 4700Ω; R_Array_SIP10
RN2, RN4: 1KΩ; R_Array_SIP9
RN3: 1kΩ; R_Array_SIP10
RN5: 2.2kΩ; R_Array_SIP10
SW1: IO PAGE SELECT; SW_DIP_SPSTx08_Slide_6.7x21.88mm_W7.62mm_P2.54mm_LowProfile
SW2: IO ADDRESS SELECT; SW_DIP_SPSTx08_Slide_6.7x21.88mm_W7.62mm_P2.54mm_LowProfile
SW3: RESET; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
U1: 74LS93; DIP-14_W7.62mm_Socket_LongPads
U2, U8, U10: 74LS244; DIP-20_W7.62mm_Socket_LongPads
U3: 74LS04; DIP-14_W7.62mm_Socket_LongPads
U4, U7: 74LS688; DIP-20_W7.62mm_Socket_LongPads
U5: 74LS245; DIP-20_W7.62mm_Socket_LongPads
U6: MC6809; DIP-40_W15.24mm_LongPads
U9: 74LS00; DIP-14_W7.62mm_Socket_LongPads
U11: 74LS74; DIP-14_W7.62mm_Socket_LongPads
U12: 74LS07; DIP-14_W7.62mm_Socket_LongPads

Connections:
68TOGGLE: U9.11, U11.3 (C), U11.11 (C)
6809EN: J2.3, U3.8, U3.13
6809IO: U2.6 (I2a), U3.6
A0: J4.21, U7.2 (P0), U8.18 (O0a)
A1: J4.19, U7.4 (P1), U8.16 (O1a)
A2: J4.17, U7.6 (P2), U8.14 (O2a)
A3: J4.15, U7.8 (P3), U8.12 (O3a)
A4: J4.13, U7.11 (P4), U8.9 (O0b)
A5: J4.11, U7.13 (P5), U8.7 (O1b)
A6: J4.9, U7.15 (P6), U8.5 (O2b)
A7: J4.7, U7.17 (P7), U8.3 (O3b)
A8: J4.5, U4.2 (P0), U10.18 (O0a)
A9: J4.3, U4.4 (P1), U10.16 (O1a)
A10: J4.1, U4.6 (P2), U10.14 (O2a)
A11: J4.2, U4.8 (P3), U10.12 (O3a)
A12: J4.4, U4.11 (P4), U10.9 (O0b)
A13: J4.6, U4.13 (P5), U10.7 (O1b)
A14: J4.8, U4.15 (P6), U10.5 (O2b)
A15: J4.10, U4.17 (P7), U10.3 (O3b)
CLK: J1.1, J4.12, U1.14 (CP0)
CLKO: J1.2, J1.4, J1.6, J1.8, RN5.2 (R1), U6.38 (EXTAL)
CPU_~RD: U2.4 (I1a), U9.3
CPU_~WR: U2.2 (I0a), U9.6
D0: J4.28, U5.2 (A0)
D1: J4.30, U5.3 (A1)
D2: J4.24, U5.4 (A2)
D3: J4.16, U5.5 (A3)
D4: J4.14, U5.6 (A4)
D5: J4.18, U5.7 (A5)
D6: J4.20, U5.8 (A6)
D7: J4.26, U5.9 (A7)
E: U6.34 (E), U9.2, U9.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.1 (K), J3.1, J4.23, J4.43, JP1.2 (B), SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, SW2.1, SW2.2, SW2.3, SW2.4, SW2.5, SW2.6, SW2.7, SW2.8, SW3.2, U1.2 (R0(1)), U1.3 (R0(2)), U1.10 (GND), U2.10 (GND), U3.7 (GND), U4.10 (GND), U5.10 (GND), U6.1 (VSS), U6.39 (XTAL), U7.10 (GND), U8.10 (GND), U9.7 (GND), U10.10 (GND), U11.7 (GND), U12.7 (GND)
unnamed: C17.1, D7.2 (A), R5.1, R8.2, U12.1
unnamed: D1.2 (A), R1.2
unnamed: D2.1 (K), U12.6
unnamed: D2.2 (A), R2.2
unnamed: D3.1 (K), U12.8
unnamed: D3.2 (A), R3.2
unnamed: D4.1 (K), U12.10
unnamed: D4.2 (A), R4.2
unnamed: D5.1 (K), U12.12
unnamed: D5.2 (A), R6.1
unnamed: D6.1 (K), U3.12
unnamed: D6.2 (A), R7.1
unnamed: J1.3, U1.1 (CP1..3), U1.12 (Q0)
unnamed: J1.5, U1.9 (Q1)
unnamed: J1.7, U1.8 (Q2)
unnamed: JP1.1 (A), R5.2, SW3.1
unnamed: RN2.2 (R1), SW1.9, U4.18 (R7)
unnamed: RN2.3 (R2), SW1.10, U4.16 (R6)
unnamed: RN2.4 (R3), SW1.11, U4.14 (R5)
unnamed: RN2.5 (R4), SW1.12, U4.12 (R4)
unnamed: RN2.6 (R5), SW1.13, U4.9 (R3)
unnamed: RN2.7 (R6), SW1.14, U4.7 (R2)
unnamed: RN2.8 (R7), SW1.15, U4.5 (R1)
unnamed: RN2.9 (R8), SW1.16, U4.3 (R0)
unnamed: RN3.2 (R1), U6.4 (~FIRQ)
unnamed: RN3.3 (R2), U6.33 (~DMA/BREQ)
unnamed: RN3.4 (R3), U6.40 (~HALT)
unnamed: RN3.5 (R4), U6.36 (MRDY)
unnamed: RN4.2 (R1), SW2.9, U7.18 (R7)
unnamed: RN4.3 (R2), SW2.10, U7.16 (R6)
unnamed: RN4.4 (R3), SW2.11, U7.14 (R5)
unnamed: RN4.5 (R4), SW2.12, U7.12 (R4)
unnamed: RN4.6 (R5), SW2.13, U7.9 (R3)
unnamed: RN4.7 (R6), SW2.14, U7.7 (R2)
unnamed: RN4.8 (R7), SW2.15, U7.5 (R1)
unnamed: RN4.9 (R8), SW2.16, U7.3 (R0)
unnamed: RN5.3 (R2), U5.18 (B0), U6.31 (D0)
unnamed: RN5.4 (R3), U5.17 (B1), U6.30 (D1)
unnamed: RN5.5 (R4), U5.16 (B2), U6.29 (D2)
unnamed: RN5.6 (R5), U5.15 (B3), U6.28 (D3)
unnamed: RN5.7 (R6), U5.14 (B4), U6.27 (D4)
unnamed: RN5.8 (R7), U5.13 (B5), U6.26 (D5)
unnamed: RN5.9 (R8), U5.12 (B6), U6.25 (D6)
unnamed: RN5.10 (R9), U5.11 (B7), U6.24 (D7)
unnamed: U3.2, U9.5
unnamed: U3.3, U6.23 (A15)
unnamed: U3.10, U9.9, U9.10
unnamed: U3.11, U7.19 (P=R)
unnamed: U6.8 (A0), U8.2 (I0a)
unnamed: U6.9 (A1), U8.4 (I1a)
unnamed: U6.10 (A2), U8.6 (I2a)
unnamed: U6.11 (A3), U8.8 (I3a)
unnamed: U6.12 (A4), U8.11 (I0b)
unnamed: U6.13 (A5), U8.13 (I1b)
unnamed: U6.14 (A6), U8.15 (I2b)
unnamed: U6.15 (A7), U8.17 (I3b)
unnamed: U9.8, U9.12, U9.13
unnamed: U6.16 (A8), U10.2 (I0a)
unnamed: U6.17 (A9), U10.4 (I1a)
unnamed: U6.18 (A10), U10.6 (I2a)
unnamed: U6.19 (A11), U10.8 (I3a)
unnamed: U6.20 (A12), U10.11 (I0b)
unnamed: U6.21 (A13), U10.13 (I1b)
unnamed: U6.22 (A14), U10.15 (I2b)
unnamed: U3.4, U10.17 (I3b)
unnamed: U11.2 (D), U11.6 (~Q)
unnamed: U11.5 (Q), U12.3
unnamed: U11.8 (~Q), U11.12 (D)
RD/~WR: U3.1, U5.1 (A->B), U6.32 (R/~W), U9.1
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, D7.1 (K), J4.22, J4.42, R1.1, R2.1, R3.1, R4.1, R6.2, R7.2, R8.1, RN1.1 (common), RN2.1 (common), RN3.1 (common), RN4.1 (common), RN5.1 (common), U1.5 (VCC), U2.20 (VCC), U3.14 (VCC), U4.20 (VCC), U5.20 (VCC), U6.7 (VCC), U7.20 (VCC), U8.20 (VCC), U9.14 (VCC), U10.20 (VCC), U11.1 (~R), U11.13 (~R), U11.14 (VCC), U12.14 (VCC)
_INT: J4.32, U2.11 (I0b)
_NMI: J4.34, U2.13 (I1b)
~6809ACTIVE: J3.3, U11.9 (Q)
~6809EN: J3.2, U2.1 (OEa), U2.19 (OEb), U3.9, U4.1 (G), U5.19 (CE), U8.1 (OEa), U8.19 (OEb), U10.1 (OEa), U10.19 (OEb)
~6809INT: RN1.4 (R3), U2.9 (O0b), U6.3 (~IRQ), U12.11
~6809IO: U2.8 (I3a), U3.5, U4.19 (P=R)
~6809NMI: RN1.3 (R2), U2.7 (O1b), U6.2 (~NMI), U12.13
~6809RST: J2.2, RN1.2 (R1), U6.37 (~RESET)
~BUSACK: J4.35, RN1.10 (R9)
~BUSRQ: J4.31, RN1.6 (R5), U12.4
~HALT: J4.36, RN1.9 (R8)
~IORQ: J4.40, RN3.6 (R5), U2.12 (O3a), U7.1 (G), U12.5
~M1: J4.27, RN1.7 (R6)
~MREQ: J4.38, RN3.7 (R6), U2.14 (O2a), U12.9
~RD: J4.39, RN3.9 (R8), U2.16 (O1a)
~RESET: J2.1, J4.29, U11.4 (~S), U11.10 (~S), U12.2
~RFSH: J4.25, RN1.8 (R7)
~WAIT: J4.33, RN1.5 (R4)
~WR: J4.37, RN3.8 (R7), U2.18 (O0a)

Notes on the sheet:
CLK/4
CLK/8
CLK/2
V1.2 10/2/2022
CLK
1&2 - stand alone 2&3 - secondary CPU
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
Board: 2 copper layers, 100.0 x 100.0 mm, 57 parts (0 on the bottom side), 122 nets.

## KiCad design 6502PROC/hardware/Z8065C02.kicad_pcb

File 6502PROC/README.md (part):

# MBC65C02
65C02 processor board (hardware and software) for the Nhyodyne computer system

## BUGS
* the WDC 65C02 cannot be used in the board, it needs to be an older chip.  I recently found a document from a builder that was working on a PET clone that (I believe) may give a clue to resolving this issue.

> . . . s. Additionally, although for all
practical purposes here the W65C02 is, functionally, entirely equivalent to the original 6502,
it is not a direct drop-in replacement. It has slightly different pin functions, different, more
stringent timing requirements due to its ability to run several times faster than the original
NMOS 6502 and it is a CMOS part with CMOS-level, rather than TTL-level compatible I/O
thresholds. The potential timing incompatibility mostly relates to memory write operations and how
briefly (only 10 ns) valid data is guaranteed to remain on the data bus upon the falling edge of
the system clock (time THW). If your memory write strobe decoding doesn’t have time to react
before the data disappears from the data bus you’re going to have trouble with memory write
operations! If you peruse my circuit diagrams you’ll notice that a pair of 74HCT244 driver
chips directly buffer the W65C02S’s data I/O pins to the systems data bus. These chips
provide CMOS-level to TTL-level threshold conversion and add critical, delayed time
extension to THW. To doubly ensure that the memory write strobe is available well ahead of
schedule, it is decoded by a super-fast 74AC family device. . . . .

# JUMPER SETTINGS
## General
        J1 - Enable
                1&2 Only CPU
                2&3 Secondary CPU

        J2 - Clock Divider
                1&2 CLK/2
                3&4 CLK/4
                5&6 CLK/8
                7&8 CLK/16
                9&10 CLK

        J4 - Reset
                1&2 Only CPU
                2&3 Secondary CPU

        JP1 - External Reset Switch

        SW1 - IO Page select
                This maps the IO addresses $00-$FF into the 6502 memory space.  Note that
                the 6502 has address line A15 inverted in order to maintain compatibility
                with the Nhyodyne ROM and RAM cards.   Therefore the MSB (SW8) is inverted.  Most test applications for this board expect an IO page of $03 ($0300-$03FF).Leading to a default setting of:
                1-off
                2-off
                3-on
                4-on
                5-on
                6-on
                7-on
                8-off

        SW2 - Reset

        SW2 - 6502 toggle address
                This setting sets the IO port that toggles the 6502 in and out of control when it is a secondary CPU.  When it is the only CPU in the system this setting has no effect. Most test applications for this board expect an IO address of $FF ($0300-$03FF).   Reading this IO port will toggle the 6502 active/inactive.
                Leading to a default setting of:
                1-off
                2-off
                3-off
                4-off
                5-off
                6-off
                7-off
                8-off

# BOM (V1.4)

Qty|Reference(s)|Value
--- | --- | ---
5|C1, C2, C16, C17, C18|10�F electrolytic
13|C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15|0.1�F
1|D1|Device:LED
1|D2|1N4148
1|D3|Device:LED
1|D4|Device:LED
1|D5|Device:LED
1|D6|Device:LED
1|D7|Device:LED
1|J1|Connector 01x03 Male  Rt angle
1|J2|Connector 02x04 Male  Rt angle
1|J3|Connector  01x03 Male  Rt angle
1|J4|Connector 02x25 Male Rt angle
1|JP1|Jumperx2
1|R1|3.3K
1|R2|10
6|R3, R5, R6, R7, R8, R9|470
1|R4|10K
1|RN1|4700 Network 09
2|RN2, RN5|1K Network 08
1|RN3|1K Network 05
1|RN4|2.2K Network 09
1|SW1|Switch:SW_DIP_x08
1|SW2|Switch:SW_DIP_x08
1|SW3|Switch:SW_Push
3|U1, U8, U9|74LS244
1|U2|74LS93
1|U3|74LS32
1|U4|74LS04
2|U5, U10|74LS688
1|U6|65CE02
1|U7|74LS245
1|U11|74LS74
1|U12|74LS07

# SOFTWARE
### HI
This is a quick program that will print a "Hi" message to the UART then return control to the Z80.  It does not require the stack to be available and is pretty much the simplest code imaginable. :)   "Hi" requires that the UART is properly initialized.

This requires the SBC to be secondary to a Z80 SBC.

the HI.hex file can be loaded from the monitor. Ensure that jumpers J1 and J4 are set for 2&3, the 6502 toggle IO address is set for $FF and the 65C02 board is set for IOPage 03.
        * remember that bit A15 is inverted on the board so the dip switch is set to $83.

To run from the MBC Z80 monitor

first set the MPCL to allow RAM in the low bank
```
>O 7C 80
>O 78 80
```
Then load the .HEX file.
```
>L
```

Finally transfer control to the 65C02 by reading the toggle register
```
>I FF
```

### SCREAM
This is a quick program that can be put on a ROM to test the 65C02 board. It will output a continuous stream of "A" at 9600 baud from the UART. It does not require the stack to be available and is pretty much the simplest code imaginable. :)
"SCREAM" initializes the UART for 9600,n,8,1.

It assumes that the 65C02 board is set for IOPage 03.
        * remember that bit A15 is inverted on the board so the dip switch is set to $83.

The scrm.com file can be run from CP/M or the scream.hex file can be loaded from the monitor. Ensure that jumpers J1 and J4 are set for 2&3, the 6502 toggle IO address is set for $FF and the 65C02 board is set for IOPage 03.
        * remember that bit A15 is inverted on the board so the dip switch is set to $83.

 ** Note that this program will change the baud rate to 9600.

To run from the MBC Z80 monitor

first set the MPCL to allow RAM in the low bank
```
>O 7C 80
>O 78 80
```
Then load the .HEX file.
```
>L
```

Finally transfer control to the 65C02 by reading the toggle register
```
>I FF
```

The '02 should reset and run this program

### MONITOR
This is a simple monitor program, see the "monitor" section of this document for usage instructions. "Monitor" requires that the UART is properly initialized as it would be when the SBC is secondary to the Z80 proc board.  If you are running this board as the primary CPU, see the Firmware section.

It assumes that the 65C02 board is set for IOPage 03.
        * remember that bit A15 is inverted on the board so the dip switch is set to $83.

The monitor.com file can be run from CP/M or the monitor.hex file can be loaded from the Z80 monitor. Ensure that jumpers J1 and J4 are set for 2&3, the 6502 toggle IO address is set for $FF and the 65C02 board is set for IOPage 03.
        * remember that bit A15 is inverted on the board so the dip switch is set to $83.

To run from the MBC Z80 monitor

first set the MPCL to allow RAM in the low bank
```
>O 7C 80
>O 78 80
```
Then load the .HEX file.
```
>L
```

Finally transfer control to the 65C02 by reading the toggle register
```
>I FF
```

## Using the 6502 MONITOR
The Nhyodyne system now uses the SuperMON monitor.  It is a powerful machine language monitor that will allow you to view and manipulate the 6502 operating environment.

```
 INSERT SUPERMON DOCS HERE
```

## Using DOS65
        DOS/65 is provided as the operating system for the Nhyodyne 65C02 board.  See the DOS/65 documentation for more information on how to use DOS/65.

        If you are running the 6502 board as a secondary CPU, the CP/M program DOS65.com will load DOS/65 and transition control from Z80 CP/M to 65c02 DOS/65.  DOS65.COM also requires DOS65DRV.SYS on the same drive as it contains all of the device drivers that are loaded into another RAM bank.

        DOS/65 will read and write from HD_512 style ROMWBW slices and CP/M images. HD_1024 images are not supported.

        Rather than running .COM files, DOS/65 will run .CO6 files.

        currently DOS/65 supports PPIDE, serial, and DSKYNG devices

        DOS/65 utility programs:
        CPM.CO6 - return control to the Z80 and Boot CPM into a sane state.
        ASSIGN.CO6 - dynamically adjust drive mapping
        SEDIT.CO6 - Text editor (only partially working)

Parts:
C1, C2, C16, C17, C18: 10µF; CP_Radial_D4.0mm_P2.00mm
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15: 0.1µF; C_Disc_D7.5mm_W2.5mm_P5.00mm
D1: POWER; LED_D3.0mm
D2: 1N4148; D_A-405_P7.62mm_Horizontal
D3: MR; LED_D3.0mm
D4: IR; LED_D3.0mm
D5: INT; LED_D3.0mm
D6: NMI; LED_D3.0mm
D7: 6502; LED_D3.0mm
J1: 6502 RESET; PinHeader_1x03_P2.54mm_Horizontal
J2: Clock Speed; PinHeader_2x04_P2.54mm_Horizontal
J3: 6502 ONLY; PinHeader_1x03_P2.54mm_Horizontal
J4: MBC Bus Connector; PinHeader_2x25_P2.54mm_Horizontal
JP1: RESET; PinHeader_1x02_P2.54mm_Vertical
R1: 3.3KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 10Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R5, R6, R7, R8, R9: 470Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 10KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RN1: 4700Ω; R_Array_SIP10
RN2, RN5: 1KΩ; R_Array_SIP9
RN3: 1KΩ; R_Array_SIP6
RN4: 2.2KΩ; R_Array_SIP10
SW1: IO PAGE SELECT; SW_DIP_SPSTx08_Slide_6.7x21.88mm_W7.62mm_P2.54mm_LowProfile
SW2: IO ADDRESS SELECT; SW_DIP_SPSTx08_Slide_6.7x21.88mm_W7.62mm_P2.54mm_LowProfile
SW3: RESET; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
U1, U8, U9: 74LS244; DIP-20_W7.62mm_Socket_LongPads
U2: 74LS93; DIP-14_W7.62mm_Socket_LongPads
U3: 74LS32; DIP-14_W7.62mm_Socket_LongPads
U4: 74LS04; DIP-14_W7.62mm_Socket_LongPads
U5, U10: 74LS688; DIP-20_W7.62mm_Socket_LongPads
U6: 65CE02; DIP-40_W15.24mm_Socket_LongPads
U7: 74LS245; DIP-20_W7.62mm_Socket_LongPads
U11: 74LS74; DIP-14_W7.62mm_Socket_LongPads
U12: 74LS07; DIP-14_W7.62mm_Socket_LongPads

Connections:
65TOGGLE: U3.11, U11.3 (C), U11.11 (C)
6502EN: J1.3, U4.8, U4.13
6502IO: U1.6 (I2a), U4.6
6502RST: J1.2, RN1.2 (R1), U6.40 (~RES)
A0: J4.21, U8.18 (O0a), U10.2 (P0)
A1: J4.19, U8.16 (O1a), U10.4 (P1)
A2: J4.17, U8.14 (O2a), U10.6 (P2)
A3: J4.15, U8.12 (O3a), U10.8 (P3)
A4: J4.13, U8.9 (O0b), U10.11 (P4)
A5: J4.11, U8.7 (O1b), U10.13 (P5)
A6: J4.9, U8.5 (O2b), U10.15 (P6)
A7: J4.7, U8.3 (O3b), U10.17 (P7)
A8: J4.5, U5.2 (P0), U9.18 (O0a)
A9: J4.3, U5.4 (P1), U9.16 (O1a)
A10: J4.1, U5.6 (P2), U9.14 (O2a)
A11: J4.2, U5.8 (P3), U9.12 (O3a)
A12: J4.4, U5.11 (P4), U9.9 (O0b)
A13: J4.6, U5.13 (P5), U9.7 (O1b)
A14: J4.8, U5.15 (P6), U9.5 (O2b)
A15: J4.10, U5.17 (P7), U9.3 (O3b)
CLK: J4.12, U2.14 (CP0)
CLKO: J2.2, J2.4, J2.6, J2.8, RN4.10 (R9), U6.37 (ϕ0)
D0: J4.28, U7.2 (A0)
D1: J4.30, U7.3 (A1)
D2: J4.24, U7.4 (A2)
D3: J4.16, U7.5 (A3)
D4: J4.14, U7.6 (A4)
D5: J4.18, U7.7 (A5)
D6: J4.20, U7.8 (A6)
D7: J4.26, U7.9 (A7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D1.1 (K), J3.1, J4.23, J4.43, JP1.2 (B), SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, SW2.1, SW2.2, SW2.3, SW2.4, SW2.5, SW2.6, SW2.7, SW2.8, SW3.2, U1.10 (GND), U2.2 (R0(1)), U2.3 (R0(2)), U2.10 (GND), U3.7 (GND), U4.7 (GND), U5.10 (GND), U6.1 (VSS), U6.21 (VSS), U7.10 (GND), U8.10 (GND), U9.10 (GND), U10.10 (GND), U11.7 (GND), U12.7 (GND)
ICLK: U3.1, U3.5, U3.9, U6.3 (ϕ1)
unnamed: C2.1, D2.2 (A), R2.1, R4.2, U12.1
unnamed: D1.2 (A), R3.2
unnamed: D3.1 (K), U12.6
unnamed: D3.2 (A), R5.2
unnamed: D4.1 (K), U12.8
unnamed: D4.2 (A), R6.2
unnamed: D5.1 (K), U12.10
unnamed: D5.2 (A), R7.2
unnamed: D6.1 (K), U12.12
unnamed: D6.2 (A), R8.2
unnamed: D7.1 (K), U4.12
unnamed: D7.2 (A), R9.2
unnamed: J2.1, U2.1 (CP1..3), U2.12 (Q0)
unnamed: J2.3, U2.9 (Q1)
unnamed: J2.5, U2.8 (Q2)
unnamed: J2.7, U2.11 (Q3)
unnamed: JP1.1 (A), R2.2, SW3.1
unnamed: R1.1, U6.2 (RDY)
unnamed: RN2.2 (R1), SW1.9, U5.18 (R7)
unnamed: RN2.3 (R2), SW1.10, U5.16 (R6)
unnamed: RN2.4 (R3), SW1.11, U5.14 (R5)
unnamed: RN2.5 (R4), SW1.12, U5.12 (R4)
unnamed: RN2.6 (R5), SW1.13, U5.9 (R3)
unnamed: RN2.7 (R6), SW1.14, U5.7 (R2)
unnamed: RN2.8 (R7), SW1.15, U5.5 (R1)
unnamed: RN2.9 (R8), SW1.16, U5.3 (R0)
unnamed: RN3.2 (R1), U6.38 (~SO)
unnamed: RN4.2 (R1), U6.33 (D0), U7.18 (B0)
unnamed: RN4.3 (R2), U6.32 (D1), U7.17 (B1)
unnamed: RN4.4 (R3), U6.31 (D2), U7.16 (B2)
unnamed: RN4.5 (R4), U6.30 (D3), U7.15 (B3)
unnamed: RN4.6 (R5), U6.29 (D4), U7.14 (B4)
unnamed: RN4.7 (R6), U6.28 (D5), U7.13 (B5)
unnamed: RN4.8 (R7), U6.27 (D6), U7.12 (B6)
unnamed: RN4.9 (R8), U6.26 (D7), U7.11 (B7)
unnamed: RN5.2 (R1), SW2.9, U10.18 (R7)
unnamed: RN5.3 (R2), SW2.10, U10.16 (R6)
unnamed: RN5.4 (R3), SW2.11, U10.14 (R5)
unnamed: RN5.5 (R4), SW2.12, U10.12 (R4)
unnamed: RN5.6 (R5), SW2.13, U10.9 (R3)
unnamed: RN5.7 (R6), SW2.14, U10.7 (R2)
unnamed: RN5.8 (R7), SW2.15, U10.5 (R1)
unnamed: RN5.9 (R8), SW2.16, U10.3 (R0)
unnamed: U1.2 (I0a), U3.3
unnamed: U1.4 (I1a), U3.8
unnamed: U3.6, U5.1 (G)
unnamed: U3.10, U4.2
unnamed: U3.12, U3.13, U4.10
unnamed: U4.3, U6.25 (A15)
unnamed: U4.4, U9.17 (I3b)
unnamed: U6.9 (A0), U8.2 (I0a)
unnamed: U6.10 (A1), U8.4 (I1a)
unnamed: U6.11 (A2), U8.6 (I2a)
unnamed: U6.12 (A3), U8.8 (I3a)
unnamed: U6.13 (A4), U8.11 (I0b)
unnamed: U6.14 (A5), U8.13 (I1b)
unnamed: U6.15 (A6), U8.15 (I2b)
unnamed: U6.16 (A7), U8.17 (I3b)
unnamed: U6.17 (A8), U9.2 (I0a)
unnamed: U6.18 (A9), U9.4 (I1a)
unnamed: U6.19 (A10), U9.6 (I2a)
unnamed: U6.20 (A11), U9.8 (I3a)
unnamed: U6.22 (A12), U9.11 (I0b)
unnamed: U6.23 (A13), U9.13 (I1b)
unnamed: U6.24 (A14), U9.15 (I2b)
unnamed: U4.11, U10.19 (P=R)
unnamed: U11.2 (D), U11.6 (~Q)
unnamed: U11.5 (Q), U12.3
unnamed: U11.8 (~Q), U11.12 (D)
VCC: C1.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, D2.1 (K), J4.22, J4.42, R1.2, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, RN1.1 (common), RN2.1 (common), RN3.1 (common), RN4.1 (common), RN5.1 (common), U1.20 (VCC), U2.5 (VCC), U3.14 (VCC), U4.14 (VCC), U5.20 (VCC), U6.8 (VCC), U7.20 (VCC), U8.20 (VCC), U9.20 (VCC), U10.20 (VCC), U11.1 (~R), U11.13 (~R), U11.14 (VCC), U12.14 (VCC)
_6502ACTIVE: J3.3, U11.9 (Q)
_6502EN: J3.2, U1.1 (OEa), U1.19 (OEb), U3.4, U4.9, U7.19 (CE), U8.1 (OEa), U8.19 (OEb), U9.1 (OEa), U9.19 (OEb)
_6502INT: RN1.4 (R3), U1.9 (O0b), U6.4 (~IRQ), U12.11
_6502IO: U1.8 (I3a), U4.5, U5.19 (P=R)
_6502NMI: RN1.3 (R2), U1.7 (O1b), U6.6 (~NMI), U12.13
_6502WR: U3.2, U4.1, U6.34 (R/~W), U7.1 (A->B)
_BUSACK: J4.35, RN1.10 (R9)
_BUSRQ: J4.31, RN1.6 (R5), U12.4
_HALT: J4.36, RN1.9 (R8)
_INT: J4.32, U1.11 (I0b)
_IORQ: J4.40, RN3.5 (R4), U1.12 (O3a), U10.1 (G), U12.9
_M1: J4.27, RN1.7 (R6)
_MREQ: J4.38, RN3.4 (R3), U1.14 (O2a), U12.5
_NMI: J4.34, U1.13 (I1b)
_RD: J4.39, RN3.6 (R5), U1.16 (O1a)
_RESET: J1.1, J4.29, U11.4 (~S), U11.10 (~S), U12.2
_RFSH: J4.25, RN1.8 (R7)
_WAIT: J4.33, RN1.5 (R4)
_WR: J4.37, RN3.3 (R2), U1.18 (O0a)

Notes on the sheet:
CLK/4
1&2 - stand alone 2&3 - secondary CPU
CLK/2
CLK/8
V1.4 10/2/2022
CLK/16
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
Board: 2 copper layers, 100.0 x 100.0 mm, 59 parts (0 on the bottom side), 121 nets.
