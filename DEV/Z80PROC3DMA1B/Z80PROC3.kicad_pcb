# Repository lynchaj/nhyodyne (continued)

## KiCad design Z80DMA3/Z80DMA.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: 0.1u; C_Disc_D7.0mm_W2.5mm_P5.00mm
C17: 47uF; CP_Radial_D5.0mm_P2.50mm
D1, D2, D3, D4, D5: LED; LED_D3.0mm
H1, H2: BRACKET; MountingHole_2.2mm_M2_Pad
K1: EXT DMA; PinHeader_1x03_P2.54mm_Horizontal
K2: INT SEL; PinHeader_1x03_P2.54mm_Vertical
LINK1: LINK; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
P1: Z80 BUS BACKPLANE; Pin_Header_Angled_2x25_Pitch2.54mm
P2: SPARES; Pin_Header_Straight_1x10_Pitch2.54mm
P3: DAISY CHAIN; PinHeader_1x05_P2.54mm_Vertical
R1: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R5, R6, R13: 4K7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R7, R12, R14, R15: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8, R9, R10, R11: 1K8; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1: 4K7; R_Array_SIP9
SW1: IO PORT ADDR; SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm
U1: 74LS08; DIP-14_W7.62mm
U2, U7, U8: 74LS244; DIP-20_W7.62mm
U3: 74LS688; DIP-20_W7.62mm
U4: 74LS32; DIP-14_W7.62mm
U5: 74LS04; DIP-14_W7.62mm
U6: 74LS27; DIP-14_W7.62mm
U9: 74LS241; DIP-20_W7.62mm
U10: 74LS245; DIP-20_W7.62mm
U11: DMA-PLCC-44-CMOS; PLCC-44_THT-Socket; Manufacturer_Part_Number Z84C4206PEG; Mouser Part Number 692-Z84C4206PEG
U12: SN74LS07N; DIP-14_W7.62mm
U13: 74LS175; DIP-16_W7.62mm
U14: 74LS139; DIP-16_W7.62mm
U15: 74LS157; DIP-16_W7.62mm
U16: ATtiny13-20PU; DIP-8_W7.62mm

Connections:
/B_A0: P1.21, U7.18 (O0a), U14.2 (A0)
/B_A1: P1.19, U3.4 (P1), U7.16 (O1a)
/B_A2: P1.17, U3.6 (P2), U7.14 (O2a)
/B_A3: P1.15, U3.8 (P3), U7.12 (O3a)
/B_A4: P1.13, U3.11 (P4), U7.9 (O0b)
/B_A5: P1.11, U3.13 (P5), U7.7 (O1b)
/B_A6: P1.9, U3.15 (P6), U7.5 (O2b)
/B_A7: P1.7, U3.17 (P7), U7.3 (O3b)
/B_A8: P1.5, U8.18 (O0a)
/B_A9: P1.3, U8.16 (O1a)
/B_A10: P1.1, U8.14 (O2a)
/B_A11: P1.2, U8.12 (O3a)
/B_A12: P1.4, U8.9 (O0b)
/B_A13: P1.6, U8.7 (O1b)
/B_A14: P1.8, U8.5 (O2b)
/B_A15: P1.10, U8.3 (O3b)
/B_D0: P1.28, U10.9 (A7), U13.4 (D0)
/B_D1: P1.30, U10.8 (A6), U13.5 (D1)
/B_D2: P1.24, U10.7 (A5), U13.12 (D2)
/B_D3: P1.16, U10.6 (A4), U13.13 (D3)
/B_D4: P1.14, U10.5 (A3)
/B_D5: P1.18, U10.4 (A2)
/B_D6: P1.20, U10.3 (A1)
/B_D7: P1.26, U10.2 (A0)
/B_IEI: P3.4, R2.2, U2.13 (I1b)
/B_IEO: P3.5, U1.6
/B_PHI: P1.12, U2.8 (I3a)
/D0: U10.11 (B7), U11.39 (D0)
/D1: U10.12 (B6), U11.38 (D1)
/D2: U10.13 (B5), U11.37 (D2)
/D3: U10.14 (B4), U11.36 (D3)
/D4: U10.15 (B3), U11.35 (D4)
/D5: U10.16 (B2), U11.33 (D5)
/D6: U10.17 (B1), U11.32 (D6)
/D7: U10.18 (B0), U11.31 (D7)
/G-PLCC: LINK1.1, U11.34 (GND)
/IEI: U1.5, U2.7 (O1b), U5.5, U11.42 (IEI)
/IEO: U1.4, U6.2, U11.40 (IEO)
/PHI: R1.2, U2.12 (O3a), U11.8 (CLK)
/RDY: U5.10, U11.27 (RDY)
/RDY_IN: K1.3, U6.5
/SPARE0: P1.42, P2.1
/SPARE1: P1.44, P2.2
/SPARE2: P1.46, P2.3
/SPARE3: P1.48, P2.4
/SPARE4: P1.50, P2.5
/SPARE5: P1.49, P2.6
/SPARE6: P1.47, P2.7
/SPARE7: P1.45, P2.8
/SPARE8: P1.43, P2.9
/SPARE9: P1.41, P2.10
/~BAI: U2.14 (O2a), U6.9, U11.16 (~BAI), U15.1 (S)
/~BAO: U5.3, U11.15 (~BA0), U12.3
/~B_BAI: P3.2, U2.6 (I2a)
/~B_BAO: P3.3, U12.4
/~B_BUSAK: P1.35, P3.1
/~B_BUSRQ: P1.31, U6.10, U11.17 (~BUSREQ)
/~B_INT: K2.1, P1.32
/~B_IORQ: P1.40, U3.1 (G), U9.11 (I0b), U9.18 (O0a)
/~B_M1: P1.27, U2.2 (I0a), U3.2 (P0)
/~B_MREQ: P1.38, U9.13 (I1b), U9.16 (O1a)
/~B_NMI: K2.3, P1.34
/~B_RD: P1.39, U9.14 (O2a), U9.15 (I2b)
/~B_RESET: P1.29, U2.17 (I3b)
/~B_WAIT: P1.33, U2.11 (I0b)
/~B_WR: P1.37, U2.15 (I2b), U9.12 (O3a), U9.17 (I3b)
/~CE_DMA_BRD: U3.19 (P=R), U14.1 (E)
/~CE_DMA_IC: U4.1, U11.18 (~CE/~WAIT), U12.13, U15.4 (Za)
/~CE_DMA_RDY: U4.13, U14.5 (O1)
/~DMA_HAS_BUS: U4.5, U5.12, U7.1 (OEa), U7.19 (OEb), U8.1 (OEa), U8.19 (OEb), U9.1 (OEa), U9.19 (OEb), U12.11
/~IORQ: R11.2, U4.9, U9.2 (I0a), U9.9 (O0b), U11.11 (~IORQ)
/~M1: U2.18 (O0a), U4.10, U11.30 (~M1)
/~MREQ: R9.2, U9.4 (I1a), U9.7 (O1b), U11.14 (~MREQ)
/~PULSE: R5.2, U11.41 (~INT/PULSE), U12.1, U12.5, U16.6 (PB1)
/~PULSE_OUT: K1.1, R13.2, U12.2
/~RD: R8.2, U4.2, U5.1, U9.5 (O2b), U9.6 (I2a), U11.10 (~RD)
/~RDY: U5.11, U6.6, U12.9
/~RST: R6.1, U1.2, U2.3 (O3b), U13.1 (~Mr), U16.1 (~RESET~/PB5)
/~USR_RST: U1.1, U13.6 (~Q1)
/~WAIT: U2.9 (O0b), U15.2 (I0a)
/~WR: R10.2, U9.3 (O3b), U9.8 (I3a), U11.9 (~WR)
/~WR~b: U2.5 (O2b), U4.12
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.1 (K), D2.1 (K), H1.1, H2.1, K1.2, LINK1.2, P1.23, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, U1.7 (GND), U2.1 (OEa), U2.10 (GND), U2.19 (OEb), U3.10 (GND), U4.7 (GND), U5.7 (GND), U6.4, U6.7 (GND), U7.10 (GND), U8.10 (GND), U9.10 (GND), U10.10 (GND), U10.19 (CE), U12.7 (GND), U13.8 (GND), U14.3 (A1), U14.8 (GND), U15.8 (GND), U15.15 (E), U16.4 (GND)
unnamed: D1.2 (A), R7.1
unnamed: D2.2 (A), R12.2
unnamed: D3.1 (K), U12.12
unnamed: D3.2 (A), R14.2
unnamed: D4.1 (K), U12.8
unnamed: D4.2 (A), R15.2
unnamed: D5.1 (K), U12.10
unnamed: D5.2 (A), R4.2
unnamed: K2.2 (PM), U12.6
unnamed: R7.2, U16.7 (PB2)
unnamed: RN1.2 (R1), SW1.16, U3.18 (R7)
unnamed: RN1.3 (R2), SW1.15, U3.16 (R6)
unnamed: RN1.4 (R3), SW1.14, U3.14 (R5)
unnamed: RN1.5 (R4), SW1.13, U3.12 (R4)
unnamed: RN1.6 (R5), SW1.12, U3.9 (R3)
unnamed: RN1.7 (R6), SW1.11, U3.7 (R2)
unnamed: RN1.8 (R7), SW1.10, U3.5 (R1)
unnamed: RN1.9 (R8), U3.3 (R0)
unnamed: U1.3, U11.12 (~RESET)
unnamed: U1.9, U4.6
unnamed: U1.10, U4.3
unnamed: U1.11, U10.1 (A->B)
unnamed: U1.8, U1.12
unnamed: U1.13, U5.8
unnamed: U4.4, U5.2
unnamed: U4.8, U6.1
unnamed: U5.4, U6.11
unnamed: U5.6, U6.13
unnamed: U5.9, U6.12
unnamed: U5.13, U6.8
unnamed: U7.13 (I1b), U11.1 (A5)
unnamed: U7.11 (I0b), U11.2 (A4)
unnamed: U7.8 (I3a), U11.3 (A3)
unnamed: U7.6 (I2a), U11.4 (A2)
unnamed: U7.4 (I1a), U11.5 (A1)
unnamed: U7.2 (I0a), U11.7 (A0)
unnamed: U8.17 (I3b), U11.19 (A15)
unnamed: U8.15 (I2b), U11.20 (A14)
unnamed: U8.13 (I1b), U11.21 (A13)
unnamed: U8.11 (I0b), U11.22 (A12)
unnamed: U8.8 (I3a), U11.23 (A11)
unnamed: U8.6 (I2a), U11.24 (A10)
unnamed: U8.4 (I1a), U11.25 (A9)
unnamed: U8.2 (I0a), U11.26 (A8)
unnamed: U7.17 (I3b), U11.43 (A7)
unnamed: U7.15 (I2b), U11.44 (A6)
unnamed: U6.3, U13.2 (Q0)
unnamed: U4.11, U13.9 (Cp)
unnamed: U14.4 (O0), U15.3 (I1a)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, P1.22, R1.1, R2.1, R4.1, R5.1, R6.2, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, RN1.1 (common), U1.14 (VCC), U2.20 (VCC), U3.20 (VCC), U4.14 (VCC), U5.14 (VCC), U6.14 (VCC), U7.20 (VCC), U8.20 (VCC), U9.20 (VCC), U10.20 (VCC), U11.13 (VCC), U12.14 (VCC), U13.16 (VCC), U14.16 (VCC), U15.16 (VCC), U16.8 (VCC)

Notes on the sheet:
Note: Bus connector is mirror image of Z80 CPU pin out to mate to backplane whose connectors reflect Z80 CPU pin out.
CE / WAIT FUNCTION SELECT LOGIC WHEN DMA IS BUS MASTER CE/WAIT IS WAIT FUNCTION OTHERWISE CE/WAIT IS CHIP ENABLE WHEN WAIT FUNCTION IS SELECTED, BUS WAIT PIN IS CONNECTED TO CE/WAIT PIN
ADDRESS DIRECTION IS CONTROLLED BY STATUS OF BAI AND BAO. WHEN BAI IS ACTIVE (LOW) AND BAO IS INACTIVE (HIGH) THEN THE DMA BOARD IS THE BUS MASTER. SO IN THIS CASE DIRECTION OUT TO ECB BUS.
DATA DIRECTION CONTROL LOGIC
PORT DECODING
TRANSITION LOW WHEN BASE PORT IS ACCESSED
TRANSITION LOW WHEN SECOND PORT IS ACCESSED
OUTPUT P4 AND P5 ARE HIGH WHEN NOT ACCESSING DMA BOARD
U1D, Pin 11 = H A->B from bus U1D, Pin 11 = L B->A to bus
NOTE: ~B_INT~ AND ~B_NMI~ RELY ON PULL UP RESISTORS ON PROCESOR BOARD
P3 pins 1, 2 & 3 configures whether the board is a primary DMA or secondary DMA in the DMA priority chain. If the board is the only DMA board: Jumper 1-2 If the board is the primary DMA and there are other DMA boards: Jumper 1-2 and wire link BAO pin 3 to the next boards BAI in pin. If the board is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
DMA Transfer LED triggered whenever a DMA transfer is in progress and the pulse signal is active. DMA software needs to program the activation of the pulse signal.
Note: DMA IO Address Ports $E0-$E1 S1=off - A7 (high) S2=off - A6 (high) S3=off - A5 (high) S4=on - A4 (low) S5=on - A3 (low) S6=on - A2 (low) S7=on - A1 (low) S8=xx - A0 (xx)
SPARE GATES

Board: 2 copper layers, 100.0 x 100.0 mm, 62 parts (0 on the bottom side), 133 nets.

## KiCad design Z80VDP1A/Z80VDP1A.kicad_pcb

File Z80VDP1A/ReadMe.md:

Z80 VPD1A is a board for V9938/V9958 using discrete components for video output stage

Board: 2 copper layers, 100.0 x 100.0 mm, 93 parts (2 on the bottom side), 154 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C19, C24, C27, C33, C39, C40: 0.1u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C10, C11: 10u; CP_Radial_D5.0mm_P2.50mm
C12, C13, C14, C15: 0.22u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C22, C23: 33p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C25: 22u; CP_Radial_D5.0mm_P2.50mm
C26: 220u; CP_Radial_D6.3mm_P2.50mm
D1, D2, D3, D4: LED; LED_D3.0mm
H1, H2: BRACKET; MountingHole_2.2mm_M2_Pad
J1: VY/VCC; PinHeader_1x03_P2.54mm_Vertical
J2: INT#/NMI#; PinHeader_1x03_P2.54mm_Horizontal
J3: CSYNC; PinHeader_1x03_P2.54mm_Vertical
JP1: BUSCLK; PinHeader_1x02_P2.54mm_Vertical
JP2: OPTGND; PinHeader_1x02_P2.54mm_Vertical
JP3: OPTWAIT; PinHeader_1x02_P2.54mm_Vertical
JP4: CSYNCOPT; PinHeader_1x02_P2.54mm_Vertical
L1: INDUCTOR (BEAD); LairdTech_28C0236-0JW-10
P1: RGB TTL; PinHeader_2x05_P2.54mm_Horizontal
P2: SPARES; PinHeader_2x05_P2.54mm_Vertical
P3: Z80 BUS BACKPLANE; PinHeader_2x25_P2.54mm_Horizontal
P4: RAMDAC; PinHeader_2x08_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5: 2N3904; TO-92_HandSolder
R1, R2, R3, R5, R10, R11, R19, R22, R29: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R8, R9, R12, R20, R23: 1000; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6, R16: 0; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R15, R17, R24: 4700; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13: 680K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R14, R18, R21, R25, R30: 75; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RR1: 10K; R_Array_SIP9
SW1: IO PORT ADDR; SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm
U1, U3: 74LS244; DIP-20_W7.62mm
U2: 74LS245; DIP-20_W7.62mm
U4: 74LS688; DIP-20_W7.62mm
U5: FMS6141; SOIC-8_3.9x4.9mm_P1.27mm
U6: 74LS02; DIP-14_W7.62mm
U7: 74LS32; DIP-14_W7.62mm
U8: 74LS06; DIP-14_W7.62mm
U10: 74LS174; DIP-16_W7.62mm
U12: V9938-V9958; renesas21-DIP64-S
U13, U14, U15, U16: D41464C; DIP-18_W7.62mm
U23: LM1881; DIP-8_W7.62mm
X1: 21.47727 MHz; Crystal_HC49-4H_Vertical

Connections:
/688SEL#: U3.9, U4.1
/A0: P3.21, U1.2
/A1: P3.19, U1.4
/A2: P3.17, U1.6
/A3: P3.15, U1.8
/A4: P3.13, U1.11
/A5: P3.11, U1.13
/A6: P3.9, U1.15
/A7: P3.7, U1.17
/ACRCS#: U6.2, U7.11
/ACRWR#: U6.1, U10.9
/AD0: U12.49, U13.14, U14.14, U15.14, U16.14
/AD1: U12.50, U13.13, U14.13, U15.13, U16.13
/AD2: U12.51, U13.12, U14.12, U15.12, U16.12
/AD3: U12.52, U13.11, U14.11, U15.11, U16.11
/AD4: U12.53, U13.8, U14.8, U15.8, U16.8
/AD5: U12.54, U13.7, U14.7, U15.7, U16.7
/AD6: U12.55, U13.6, U14.6, U15.6, U16.6
/AD7: U12.56, U13.10, U14.10, U15.10, U16.10
/BLUE: Q2.2, R11.1, U12.24
/BLUE-OUT: P1.9, R21.2
/C0: P4.5, U12.19
/C1: P4.6, U12.18
/C2: P4.7, U12.17
/C3: P4.8, U12.16
/C4: P4.9, U12.15
/C5: P4.10, U12.14
/C6: P4.11, U12.13
/C7: P4.12, U12.12
/CAS0#: U12.61, U13.16, U14.16
/CAS1#: U12.60, U15.16, U16.16
/CBDR: P4.14, U12.11
/CLK: JP1.2, P3.12
/COMVID: C26.2, P1.4
/CSYNC#: J3.1, R8.1
/CSYNC-OUT: JP4.2, P1.10, U6.4
/CS_VDP#: U2.19, U3.4, U4.19, U7.10, U7.12
/D0: P3.28, U2.2
/D1: P3.30, U2.3
/D2: P3.24, U2.4
/D3: P3.16, U2.5
/D4: P3.14, U2.6
/D5: P3.18, U2.7
/D6: P3.20, U2.8
/D7: P3.26, U2.9
/DHCLK#: P4.3, U12.2
/DLCLK#: P4.4, R24.1, U12.3
/GREEN: Q3.2, R3.1, U12.22
/GREEN-OUT: P1.7, R18.2
/HSYNC#: P1.6, Q1.1, R9.1, U12.5
/INT#: J2.1, P3.32
/IORQ#: P3.40, U3.11
/LPS-WAIT#: R7.1, U6.11, U6.12, U12.26
/M1#: P3.27, U3.13
/NMI#: J2.3, P3.34
/ONE: R6.1, U12.27
/RAS#: U12.62, U13.5, U14.5, U15.5, U16.5
/RD#: P3.39, U2.1, U3.17
/RED: Q4.2, R19.1, U12.23
/RED-OUT: P1.5, R14.2
/RESET#: P3.29, U3.2
/RESVDP#: R17.1, U8.10, U12.9
/SPARE0: P2.1, P3.42
/SPARE1: P2.2, P3.44
/SPARE2: P2.3, P3.46
/SPARE3: P2.4, P3.48
/SPARE4: P2.5, P3.50
/SPARE5: P2.6, P3.49
/SPARE6: P2.7, P3.47
/SPARE7: P2.8, P3.45
/SPARE8: P2.9, P3.43
/SPARE9: P2.10, P3.41
/STATUS#: U8.3, U10.10
/VD0: U12.41, U13.2, U15.2
/VD1: U12.42, U13.3, U15.3
/VD2: U12.43, U13.15, U15.15
/VD3: U12.44, U13.17, U15.17
/VD4: U12.45, U14.2, U16.2
/VD5: U12.46, U14.3, U16.3
/VD6: U12.47, U14.15, U16.15
/VD7: U12.48, U14.17, U16.17
/VDP-RD#: U7.6, U12.31
/VDP-WR#: U7.3, U12.30
/VFILT: C25.1, C27.1, L1.2, U5.7
/VIDCS#: U7.2, U7.4, U7.8
/VINT#: R15.1, U8.5, U8.9, U12.25
/VRW#: U12.57, U13.4, U14.4, U15.4, U16.4
/VRY: U3.8, U12.8
/VSYNC: Q5.2, R22.1, U23.3
/VSYNC#: P1.8, R25.2
/VY: C24.2, C39.1, J1.1, R29.1
/WAIT#: JP3.2, P3.33
/WR#: P3.37, U3.15
/ZERO: R16.1, U1.1, U1.19, U3.1, U3.19, U13.1, U14.1, U15.1, U16.1
/bA0: U1.18, U12.29
/bA1: U1.16, U12.28
/bA2: U1.14, U6.8, U6.9, U7.9
/bA2#: U6.10, U7.13
/bA3: U1.12, U4.8
/bA4: U1.9, U4.11
/bA5: U1.7, U4.13
/bA6: U1.5, U4.15
/bA7: U1.3, U4.17
/bD0: U2.18, U10.3, U12.40
/bD1: U2.17, U10.4, U12.39
/bD2: U2.16, U10.6, U12.38
/bD3: U2.15, U10.11, U12.37
/bD4: U2.14, U10.13, U12.36
/bD5: U2.13, U10.14, U12.35
/bD6: U2.12, U12.34
/bD7: U2.11, U12.32
/bM1#: U3.7, U4.2, U4.4, U4.6
/bRD#: U3.3, U7.5
/bRESET#: U3.18, U10.1
/bWR#: U3.5, U6.3, U7.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C19.2, C22.2, C23.2, C25.2, C27.2, C33.2, C40.2, D2.1, H1.1, H2.1, JP2.2, P1.1, P1.3, P3.23, P4.1, P4.16, R13.2, R16.2, R29.2, R30.2, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, U1.10, U2.10, U3.10, U4.10, U5.3, U6.7, U7.7, U8.7, U10.8, U12.1, U12.20, U13.18, U14.18, U15.18, U16.18, U23.4
unnamed: C22.1, U12.63, X1.1
unnamed: C23.1, U12.64, X1.2
unnamed: C24.1, U5.1
unnamed: C26.1, R30.1, U5.8
unnamed: C33.1, U12.33
unnamed: C39.2, U23.2
unnamed: C40.1, R13.1, U23.6
unnamed: D1.1, U3.16
unnamed: D1.2, R1.1
unnamed: D2.2, R2.1
unnamed: D3.1, U8.4
unnamed: D3.2, R10.1
unnamed: D4.1, U8.8
unnamed: D4.2, R5.1
unnamed: J1.2, U12.21
unnamed: J2.2, U8.6
unnamed: J3.2, U12.6
unnamed: J3.3, U6.5, U6.6
unnamed: JP1.1, U3.12
unnamed: JP2.1, R3.2, R4.2, R9.2, R11.2, R12.2, R19.2, R20.2, R22.2, R23.2
unnamed: JP3.1, U8.2
unnamed: JP4.1, U23.1
unnamed: Q1.2, R8.2
unnamed: Q2.1, R12.1, R14.1
unnamed: Q3.1, R4.1, R18.1
unnamed: Q4.1, R20.1, R21.1
unnamed: Q5.1, R23.1, R25.1
unnamed: RR1.2, U4.3
unnamed: RR1.3, U4.5
unnamed: RR1.4, U4.7
unnamed: RR1.5, SW1.12, U4.9
unnamed: RR1.6, SW1.13, U4.12
unnamed: RR1.7, SW1.14, U4.14
unnamed: RR1.8, SW1.15, U4.16
unnamed: RR1.9, SW1.16, U4.18
unnamed: U6.13, U8.1
unnamed: U8.11, U10.2
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C19.1, J1.3, L1.1, P1.2, P3.22, P4.2, P4.15, Q1.3, Q2.3, Q3.3, Q4.3, Q5.3, R1.2, R2.2, R5.2, R6.2, R7.2, R10.2, R15.2, R17.2, R24.2, RR1.1, U1.20, U2.20, U3.20, U4.20, U6.14, U7.14, U8.14, U10.16, U12.58, U13.9, U14.9, U15.9, U16.9, U23.8
